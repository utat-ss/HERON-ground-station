options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: qt_gui
    id: pluto_remote_control
    output_language: python
    title: PlutoSDR Remote Control
  states: {}

blocks:
- name: cfo
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@0: 1, 0, 1, 1'
    label: Osc Freq
    start: 1e6
    step: 250e3
    stop: 6e9
    value: 435.4e6
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@0: 0, 0, 1, 1'
    label: Frequency
    start: cfo-samp_rate/2
    step: 250e3
    stop: cfo+samp_rate/2
    value: 435e6
    widget: counter
  states: {}
- name: gfsk_freq_dev
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@2: 2, 0, 1, 1'
    label: GFSK Freq Dev
    start: '1200'
    step: '200'
    stop: '4800'
    value: '2400'
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'control_tab@2: 0, 1, 3, 1'
    label: Mode
    label0: NBFM Audio
    label1: ESTTC
    label2: AX.25
    label3: AX.25 G3RUH
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@1: 0, 0, 1, 2'
    label: RX Gain
    start: '0'
    step: '0.5'
    stop: '71'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@2: 0, 0, 1, 1'
    label: Squelch (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@1: 1, 0, 1, 2'
    label: TX Gain
    start: '0'
    step: '0.25'
    stop: '89.75'
    value: '0'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@2: 1, 0, 1, 1'
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(baseband_samp_rate)
  states: {}
- name: baseband_samp_rate
  id: parameter
  parameters:
    label: baseband_samp_rate
    value: 48e3
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: baseband_samp_rate
    type: complex
  states: {}
- name: control_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0, 0, 1, 1
    label0: Control
    label1: SDR Amps
    label2: Misc
    num_tabs: '3'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: Server IP
    type: str
    value: 10.0.1.165
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: baseband_samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    gui_hint: 1,0,5,1
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: baseband_samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: 0,1,6,2
    type: complex
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_freq
    port: '8080'
    variable: freq
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_cfo
    port: '8080'
    variable: cfo
  states: {}
- name: xmlrpc_client_0_0_0
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_tx_gain
    port: '8080'
    variable: tx_gain
  states: {}
- name: xmlrpc_client_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_rx_gain
    port: '8080'
    variable: rx_gain
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0_0_0_0_1
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_volume
    port: '8080'
    variable: volume
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0_0_0_0_1_0
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_mode
    port: '8080'
    variable: mode
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0_0_0_0_1_1
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_gfsk_freq_dev
    port: '8080'
    variable: gfsk_freq_dev
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0_0_2
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_squelch_threshold
    port: '8080'
    variable: squelch_threshold
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '''tcp://''+ip+'':''+str(zmq_rx_bb)'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_1
  id: zeromq_sub_source
  parameters:
    address: '''tcp://''+ip+'':''+str(zmq_rx_audio)'
    timeout: '100'
    type: float
  states: {}
- name: zmq_rx_audio
  id: parameter
  parameters:
    label: RX audio
    type: intx
    value: '50493'
  states: {}
- name: zmq_rx_bb
  id: parameter
  parameters:
    label: RX baseband
    type: intx
    value: '52001'
  states: {}

connections:
- [zeromq_sub_source_0, '0', blocks_throttle2_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_sub_source_1, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
