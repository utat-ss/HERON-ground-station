options:
  parameters:
    author: Swarnava Ghosh
    copyright: Universitu of Toronto Aerospace Team
    description: Transmit a pure carrier wave and receive it on the other end.
    generate_options: qt_gui
    id: cw_loopback
    output_language: python
    title: CW Loopback
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 446.040e6
  states: {}
- name: rx_amp
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: rx_freq_offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: rx_if_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: rx_vga_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: tx_amp
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: tx_vga_gain
  id: variable
  parameters:
    value: '47'
  states: {}
- name: volume
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: rx_freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_MsgPairToVar_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_freq_offset
  states: {}
- name: gpredict_MsgPairToVar_0_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_vga_gain
  states: {}
- name: gpredict_MsgPairToVar_0_0_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: tx_amp
  states: {}
- name: gpredict_MsgPairToVar_0_1
  id: gpredict_MsgPairToVar
  parameters:
    target: squelch_threshold
  states: {}
- name: gpredict_MsgPairToVar_0_1_0
  id: gpredict_MsgPairToVar
  parameters:
    target: tx_vga_gain
  states: {}
- name: gpredict_MsgPairToVar_0_1_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_amp
  states: {}
- name: gpredict_MsgPairToVar_0_2
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_if_gain
  states: {}
- name: gpredict_MsgPairToVar_0_2_0
  id: gpredict_MsgPairToVar
  parameters:
    target: volume
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '52100'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/5 * 6/25
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '6'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_1
  id: soapy_hackrf_sink
  parameters:
    amp: tx_amp
    center_freq: freq
    dev_args: '"driver=hackrf,serial=9e5f"'
    samp_rate: samp_rate
    type: fc32
    vga: tx_vga_gain
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: rx_amp
    center_freq: freq + rx_freq_offset
    dev_args: '"driver=hackrf,serial=915f"'
    gain: rx_if_gain
    samp_rate: samp_rate
    type: fc32
    vga: rx_vga_gain
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://*:52101
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://*:52102
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://*:52105
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://*:52108
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_1
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://*:52103
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_1_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://*:52106
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_1_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://*:52109
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_2
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://*:52104
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_2_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://*:52107
    bind: 'True'
    timeout: '100'
  states: {}

connections:
- [analog_const_source_x_0, '0', soapy_hackrf_sink_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', network_tcp_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', blocks_multiply_xx_0, '0']
- [zeromq_pull_msg_source_0, out, gpredict_MsgPairToVar_0, inpair]
- [zeromq_pull_msg_source_0_0, out, gpredict_MsgPairToVar_0_0, inpair]
- [zeromq_pull_msg_source_0_0_0, out, gpredict_MsgPairToVar_0_0_0, inpair]
- [zeromq_pull_msg_source_0_0_0_0, out, gpredict_MsgPairToVar_0_0_0_0, inpair]
- [zeromq_pull_msg_source_0_1, out, gpredict_MsgPairToVar_0_1, inpair]
- [zeromq_pull_msg_source_0_1_0, out, gpredict_MsgPairToVar_0_1_0, inpair]
- [zeromq_pull_msg_source_0_1_0_0, out, gpredict_MsgPairToVar_0_1_0_0, inpair]
- [zeromq_pull_msg_source_0_2, out, gpredict_MsgPairToVar_0_2, inpair]
- [zeromq_pull_msg_source_0_2_0, out, gpredict_MsgPairToVar_0_2_0, inpair]

metadata:
  file_format: 1
  grc_version: 3.10.8.0
