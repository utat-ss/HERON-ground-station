options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: qt_gui
    id: hackrf_remote_control
    output_language: python
    title: HackRF Remote Control
  states: {}

blocks:
- name: cfo
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@0: 1, 0, 1, 1'
    label: Osc Freq
    start: 1e6
    step: 250e3
    stop: 6e9
    value: 435.4e6
  states: {}
- name: da
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: control_tab@2:2,0,1,1
    label: DA
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@0: 0, 0, 1, 1'
    label: Frequency
    start: cfo-samp_rate/2
    step: 250e3
    stop: cfo+samp_rate/2
    value: 435e6
    widget: counter
  states: {}
- name: lna
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: control_tab@2:1,0,1,1
    label: LNA
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: pa
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: control_tab@2:0,0,1,1
    label: PA
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: rx_amp
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 'control_tab@1: 1, 3, 1, 1'
    label: RX RF Amplifier
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: rx_if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@1: 0, 0, 1, 2'
    label: RX IF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '0'
  states: {}
- name: rx_vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@1: 1, 0, 1, 2'
    label: RX VGA Gain
    start: '0'
    step: '2'
    stop: '62'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@3: 0, 0, 1, 1'
    label: Squelch Threshold (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: tx_amp
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 'control_tab@1: 1, 2, 1, 1'
    label: TX RF Amplifier
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: tx_pwr
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'control_tab@2: 0,1,3,1'
    label: TX Power
    num_opts: '4'
    option0: '20'
    option1: '40'
    option2: '60'
    option3: '80'
    type: int
    value: '20'
    widget: radio_buttons
  states: {}
- name: tx_vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@1: 0, 2, 1, 2'
    label: TX VGA Gain
    start: '0'
    step: '1'
    stop: '47'
    value: '0'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@3: 1, 0, 1, 1'
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: baseband_samp_rate
  id: parameter
  parameters:
    label: baseband_samp_rate
    value: 48e3
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: baseband_samp_rate
    type: complex
  states: {}
- name: control_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0, 0, 1, 1
    label0: Control
    label1: SDR Amps
    label2: Toptek
    label3: Misc
    num_tabs: '4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: baseband_samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    gui_hint: 1,0,5,1
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: baseband_samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: 0,1,6,2
    type: complex
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: xmlrpc_ip
    callback: set_freq
    port: '8080'
    variable: freq
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: xmlrpc_ip
    callback: set_cfo
    port: '8080'
    variable: cfo
  states: {}
- name: xmlrpc_client_0_0_0
  id: xmlrpc_client
  parameters:
    addr: xmlrpc_ip
    callback: set_rx_if_gain
    port: '8080'
    variable: rx_if_gain
  states: {}
- name: xmlrpc_client_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: xmlrpc_ip
    callback: set_rx_vga_gain
    port: '8080'
    variable: rx_vga_gain
  states: {}
- name: xmlrpc_client_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: xmlrpc_ip
    callback: set_tx_vga_gain
    port: '8080'
    variable: tx_vga_gain
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: xmlrpc_ip
    callback: set_tx_amp
    port: '8080'
    variable: tx_amp
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: xmlrpc_ip
    callback: set_rx_amp
    port: '8080'
    variable: rx_amp
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: xmlrpc_ip
    callback: set_pa
    port: '8080'
    variable: pa
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: xmlrpc_ip
    callback: set_lna
    port: '8080'
    variable: lna
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: xmlrpc_ip
    callback: set_da
    port: '8080'
    variable: da
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: xmlrpc_ip
    callback: set_tx_pwr
    port: '8080'
    variable: tx_pwr
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0_0_0_0_1
  id: xmlrpc_client
  parameters:
    addr: xmlrpc_ip
    callback: set_volume
    port: '8080'
    variable: volume
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0_0_2
  id: xmlrpc_client
  parameters:
    addr: xmlrpc_ip
    callback: set_squelch_threshold
    port: '8080'
    variable: squelch_threshold
  states: {}
- name: xmlrpc_ip
  id: parameter
  parameters:
    label: XMLRPC Server IP
    type: str
    value: 10.0.7.91
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: zmq_baseband_stream
    timeout: '100'
    type: complex
  states: {}
- name: zmq_baseband_stream
  id: parameter
  parameters:
    label: ZMQ Baseband Stream
    type: str
    value: tcp://10.0.7.91:52001
  states: {}

connections:
- [zeromq_sub_source_0, '0', blocks_throttle2_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
