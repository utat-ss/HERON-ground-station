options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: qt_gui
    id: hackrf_remote_control
    output_language: python
    title: HackRF Remote Control
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@0: 0, 0, 1, 1'
    label: Frequency
    start: 420e6
    step: 250e3
    stop: 450e6
    value: 435e6
    widget: counter
  states: {}
- name: rx_agc
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 'control_tab@1: 0, 2, 1, 1'
    label: RX AGC
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: rx_freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@0: 1, 0, 1, 1'
    label: RX Offset
    start: '-samp_rate/2'
    step: samp_rate/200
    stop: samp_rate/2
    value: 100e3
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@1: 0, 0, 1, 2'
    label: RX Gain
    start: '0'
    step: '1'
    stop: '73'
    value: '73'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@2: 0, 0, 1, 1'
    label: Squelch Threshold (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@1: 1, 0, 1, 2'
    label: TX Gain
    start: '0'
    step: '1'
    stop: '89'
    value: '89'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@2: 1, 0, 1, 1'
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: baseband_samp_rate
  id: parameter
  parameters:
    label: baseband_samp_rate
    value: 48e3
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/swarnava/data/gs/hackrf_to_hackrf.iq
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: baseband_samp_rate
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: freq
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: rx_freq_offset
    target: rx_freq_offset
  states: {}
- name: blocks_var_to_msg_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: tx_gain
    target: tx_gain
  states: {}
- name: blocks_var_to_msg_0_1_0
  id: blocks_var_to_msg
  parameters:
    msgname: rx_agc
    target: rx_agc
  states: {}
- name: blocks_var_to_msg_0_2
  id: blocks_var_to_msg
  parameters:
    msgname: rx_gain
    target: rx_gain
  states: {}
- name: control_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0, 0, 1, 1
    label0: Control
    label1: SDR Amps
    label2: Misc
    num_tabs: '3'
  states: {}
- name: freq_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 'control_tab@0: 0, 0, 1, 1'
    label0: Frequency
    num_tabs: '1'
  states: {state: disabled}
- name: misc_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 'control_tab@0: 3, 0, 1, 1'
    label0: Misc
    num_tabs: '1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: baseband_samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    gui_hint: 1,0,5,1
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: baseband_samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: 0,1,6,2
    type: complex
  states: {}
- name: sdr_amps_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 'control_tab@0: 1, 0, 1, 1'
    label0: SDR Amps
    num_tabs: '1'
  states: {state: disabled}
- name: toptek_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 'control_tab@0: 2, 0, 1, 1'
    label0: Toptek
    num_tabs: '1'
  states: {state: disabled}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: zmq_control
    bind: 'False'
    timeout: '100'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: zmq_baseband_stream
    timeout: '100'
    type: complex
  states: {}
- name: zmq_baseband_stream
  id: parameter
  parameters:
    label: ZMQ Baseband Stream
    type: str
    value: tcp://10.0.1.165:52001
  states: {}
- name: zmq_control
  id: parameter
  parameters:
    label: ZMQ Control
    type: str
    value: tcp://10.0.1.165:52000
  states: {}

connections:
- [blocks_var_to_msg_0, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_0, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_0_0, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_1_0, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_2, msgout, zeromq_push_msg_sink_0, in]
- [zeromq_sub_source_0, '0', blocks_file_sink_0, '0']
- [zeromq_sub_source_0, '0', blocks_throttle2_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
