options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: qt_gui
    id: hackrf_remote_control
    output_language: python
    title: HackRF Remote Control
  states: {}

blocks:
- name: control_port
  id: variable
  parameters:
    value: base_port
  states: {}
- name: da
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: control_tab@2:2,0,1,1
    label: DA
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@0: 0, 0, 1, 1'
    label: Frequency
    start: 420e6
    step: 250e3
    stop: 450e6
    value: 435e6
    widget: counter
  states: {}
- name: lna
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: control_tab@2:1,0,1,1
    label: LNA
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: pa
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: control_tab@2:0,0,1,1
    label: PA
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: rx_amp
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 'control_tab@1: 1, 3, 1, 1'
    label: RX RF Amplifier
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: rx_freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@0: 1, 0, 1, 1'
    label: RX Offset
    start: '-samp_rate/2'
    step: samp_rate/200
    stop: samp_rate/2
    value: 100e3
  states: {}
- name: rx_if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@1: 0, 0, 1, 2'
    label: RX IF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '40'
  states: {}
- name: rx_vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@1: 1, 0, 1, 2'
    label: RX VGA Gain
    start: '0'
    step: '1'
    stop: '62'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@3: 0, 0, 1, 1'
    label: Squelch Threshold (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: stream_port
  id: variable
  parameters:
    value: base_port+1
  states: {}
- name: tx_amp
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 'control_tab@1: 1, 2, 1, 1'
    label: TX RF Amplifier
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: tx_pwr
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'control_tab@2: 0,1,3,1'
    label: TX Power
    num_opts: '4'
    option0: '20'
    option1: '40'
    option2: '60'
    option3: '80'
    type: int
    value: '20'
    widget: radio_buttons
  states: {}
- name: tx_vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@1: 0, 2, 1, 2'
    label: TX VGA Gain
    start: '0'
    step: '1'
    stop: '47'
    value: '47'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@3: 1, 0, 1, 1'
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: base_port
  id: parameter
  parameters:
    label: Base Port
    type: intx
    value: '52000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/swarnava/data/gs/hackrf_to_hackrf.iq
    type: complex
  states: {state: disabled}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: freq
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: rx_freq_offset
    target: rx_freq_offset
  states: {}
- name: blocks_var_to_msg_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: rx_vga_gain
    target: rx_vga_gain
  states: {}
- name: blocks_var_to_msg_0_1
  id: blocks_var_to_msg
  parameters:
    msgname: squelch_threshold
    target: squelch_threshold
  states: {}
- name: blocks_var_to_msg_0_1_0
  id: blocks_var_to_msg
  parameters:
    msgname: tx_vga_gain
    target: tx_vga_gain
  states: {}
- name: blocks_var_to_msg_0_2
  id: blocks_var_to_msg
  parameters:
    msgname: rx_if_gain
    target: rx_if_gain
  states: {}
- name: blocks_var_to_msg_0_3
  id: blocks_var_to_msg
  parameters:
    msgname: volume
    target: volume
  states: {}
- name: blocks_var_to_msg_0_3_0
  id: blocks_var_to_msg
  parameters:
    msgname: tx_amp
    target: tx_amp
  states: {}
- name: blocks_var_to_msg_0_3_1
  id: blocks_var_to_msg
  parameters:
    msgname: rx_amp
    target: rx_amp
  states: {}
- name: blocks_var_to_msg_0_3_1_0
  id: blocks_var_to_msg
  parameters:
    msgname: pa
    target: pa
  states: {}
- name: blocks_var_to_msg_0_3_1_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: lna
    target: lna
  states: {}
- name: blocks_var_to_msg_0_3_1_0_1
  id: blocks_var_to_msg
  parameters:
    msgname: da
    target: da
  states: {}
- name: blocks_var_to_msg_0_3_1_0_1_0
  id: blocks_var_to_msg
  parameters:
    msgname: tx_pwr
    target: tx_pwr
  states: {}
- name: control_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0, 0, 1, 1
    label0: Control
    label1: SDR Amps
    label2: Toptek
    label3: Misc
    num_tabs: '4'
  states: {}
- name: freq_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 'control_tab@0: 0, 0, 1, 1'
    label0: Frequency
    num_tabs: '1'
  states: {state: disabled}
- name: ip
  id: parameter
  parameters:
    label: IP Address
    type: str
    value: 10.0.7.38
  states: {}
- name: misc_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 'control_tab@0: 3, 0, 1, 1'
    label0: Misc
    num_tabs: '1'
  states: {state: disabled}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: ip
    port: stream_port
    server: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 48e3
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    gui_hint: 1,0,5,1
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 48e3
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: 0,1,6,2
    type: complex
  states: {}
- name: sdr_amps_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 'control_tab@0: 1, 0, 1, 1'
    label0: SDR Amps
    num_tabs: '1'
  states: {state: disabled}
- name: toptek_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 'control_tab@0: 2, 0, 1, 1'
    label0: Toptek
    num_tabs: '1'
  states: {state: disabled}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://"+ip+":"+str(control_port)'
    bind: 'False'
    timeout: '100'
  states: {}

connections:
- [blocks_var_to_msg_0, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_0, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_0_0, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_1, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_1_0, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_2, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_3, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_3_0, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_3_1, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_3_1_0, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_3_1_0_0, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_3_1_0_1, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_3_1_0_1_0, msgout, zeromq_push_msg_sink_0, in]
- [network_tcp_source_0, '0', blocks_file_sink_0, '0']
- [network_tcp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [network_tcp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
