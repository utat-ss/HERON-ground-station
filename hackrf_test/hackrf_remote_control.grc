options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: qt_gui
    id: hackrf_remote_control
    output_language: python
    title: HackRF Remote Control
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 2
    label: Frequency
    start: 420e6
    step: 250e3
    stop: 450e6
    value: 446.040e6
    widget: counter
  states: {}
- name: rx_amp
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 5, 1, 1, 1
    label: RX RF Amplifier
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: rx_freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 2
    label: RX Offset
    start: '-samp_rate/2'
    step: samp_rate/200
    stop: samp_rate/2
    value: 100e3
  states: {}
- name: rx_if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 0, 1, 1
    label: RX IF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '40'
  states: {}
- name: rx_vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4, 0, 1, 1
    label: RX VGA Gain
    start: '0'
    step: '1'
    stop: '62'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0, 1, 2
    label: Squelch Threshold (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: tx_amp
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 4, 1, 1, 1
    label: TX RF Amplifier
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: tx_vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 1, 1, 1
    label: TX VGA Gain
    start: '0'
    step: '1'
    stop: '47'
    value: '47'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 5, 0, 1, 1
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: freq
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: rx_freq_offset
    target: rx_freq_offset
  states: {}
- name: blocks_var_to_msg_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: rx_vga_gain
    target: rx_vga_gain
  states: {}
- name: blocks_var_to_msg_0_1
  id: blocks_var_to_msg
  parameters:
    msgname: squelch_threshold
    target: squelch_threshold
  states: {}
- name: blocks_var_to_msg_0_1_0
  id: blocks_var_to_msg
  parameters:
    msgname: tx_vga_gain
    target: tx_vga_gain
  states: {}
- name: blocks_var_to_msg_0_2
  id: blocks_var_to_msg
  parameters:
    msgname: rx_if_gain
    target: rx_if_gain
  states: {}
- name: blocks_var_to_msg_0_3
  id: blocks_var_to_msg
  parameters:
    msgname: volume
    target: volume
  states: {}
- name: blocks_var_to_msg_0_3_0
  id: blocks_var_to_msg
  parameters:
    msgname: tx_amp
    target: tx_amp
  states: {}
- name: blocks_var_to_msg_0_3_1
  id: blocks_var_to_msg
  parameters:
    msgname: rx_amp
    target: rx_amp
  states: {}
- name: ip
  id: parameter
  parameters:
    label: IP Address
    type: str
    value: 127.0.0.1
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: ip
    port: '52100'
    server: 'False'
    type: complex
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '52100'
    src_zeros: 'False'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 48e3
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    gui_hint: 6, 0, 10, 2
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 48e3
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: 0, 3, 16, 2
    type: complex
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://"+ip+":52101"'
    bind: 'False'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://"+ip+":52102"'
    bind: 'False'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_0_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://"+ip+":52105"'
    bind: 'False'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_1
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://"+ip+":52103"'
    bind: 'False'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_1_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://"+ip+":52106"'
    bind: 'False'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_2
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://"+ip+":52104"'
    bind: 'False'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_3
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://"+ip+":52107"'
    bind: 'False'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_3_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://"+ip+":52108"'
    bind: 'False'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_3_1
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://"+ip+":52109"'
    bind: 'False'
    timeout: '100'
  states: {}

connections:
- [blocks_var_to_msg_0, msgout, zeromq_push_msg_sink_0, in]
- [blocks_var_to_msg_0_0, msgout, zeromq_push_msg_sink_0_0, in]
- [blocks_var_to_msg_0_0_0, msgout, zeromq_push_msg_sink_0_0_0, in]
- [blocks_var_to_msg_0_1, msgout, zeromq_push_msg_sink_0_1, in]
- [blocks_var_to_msg_0_1_0, msgout, zeromq_push_msg_sink_0_1_0, in]
- [blocks_var_to_msg_0_2, msgout, zeromq_push_msg_sink_0_2, in]
- [blocks_var_to_msg_0_3, msgout, zeromq_push_msg_sink_0_3, in]
- [blocks_var_to_msg_0_3_0, msgout, zeromq_push_msg_sink_0_3_0, in]
- [blocks_var_to_msg_0_3_1, msgout, zeromq_push_msg_sink_0_3_1, in]
- [network_tcp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [network_tcp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [network_udp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [network_udp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
