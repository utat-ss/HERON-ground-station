options:
  parameters:
    author: Swarnava Ghosh
    copyright: Universitu of Toronto Aerospace Team
    description: Transmit a pure carrier wave and receive it on the other end.
    generate_options: qt_gui
    id: cw_loopback
    output_language: python
    title: CW Loopback
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: rx_amp
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: RX RF Amplifier
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: rx_freq_offset
  id: variable_qtgui_range
  parameters:
    label: RX Offset
    start: 10e3
    step: 10e3
    stop: 200e3
    value: 10e3
  states: {}
- name: rx_if_gain
  id: variable_qtgui_range
  parameters:
    label: RX IF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '16'
  states: {}
- name: rx_vga_gain
  id: variable_qtgui_range
  parameters:
    label: RX VGA Gain
    start: '0'
    step: '1'
    stop: '62'
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tx_amp
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: TX RF Amplifier
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: tx_vga_gain
  id: variable_qtgui_range
  parameters:
    label: TX VGA Gain
    start: '0'
    step: '1'
    stop: '47'
    value: '16'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: rx_freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/5 * 6/25
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '6'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_1
  id: soapy_hackrf_sink
  parameters:
    amp: tx_amp
    center_freq: freq
    dev_args: '"driver=hackrf,serial=9e5f"'
    samp_rate: samp_rate
    type: fc32
    vga: tx_vga_gain
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: rx_amp
    center_freq: freq + rx_freq_offset
    dev_args: '"driver=hackrf,serial=915f"'
    gain: rx_if_gain
    samp_rate: samp_rate
    type: fc32
    vga: rx_vga_gain
  states: {}

connections:
- [analog_const_source_x_0, '0', soapy_hackrf_sink_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
