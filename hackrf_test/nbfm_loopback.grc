options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: qt_gui
    id: nbfm_loopback
    output_language: python
    title: NBFM Loopback
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 2
    label: Frequency
    start: 420e6
    step: 250e3
    stop: 450e6
    value: 444.8e6
    widget: counter
  states: {}
- name: rx_amp
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 5, 1, 1, 1
    label: RX RF Amplifier
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: rx_freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 2
    label: RX Offset
    start: '-samp_rate/2'
    step: samp_rate/200
    stop: samp_rate/2
    value: 100e3
  states: {}
- name: rx_if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 0, 1, 1
    label: RX IF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '16'
  states: {}
- name: rx_vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4, 0, 1, 1
    label: RX VGA Gain
    start: '0'
    step: '1'
    stop: '62'
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0, 1, 2
    label: Squelch Threshold (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: tx_amp
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 4, 1, 1, 1
    label: TX RF Amplifier
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: tx_vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 1, 1, 1
    label: TX VGA Gain
    start: '0'
    step: '1'
    stop: '47'
    value: '16'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 5, 0, 1, 1
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48e3)
    max_dev: 2.5e3
    quad_rate: int(48e3)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: int(48e3)
    fh: '-1.0'
    max_dev: 2.5e3
    quad_rate: int(48e3)
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: rx_freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_threshold
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 48e3
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    gui_hint: 6, 0, 10, 2
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 48e3
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: 0, 3, 16, 2
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '125'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '12'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_1
  id: soapy_hackrf_sink
  parameters:
    amp: tx_amp
    center_freq: freq
    dev_args: '"driver=hackrf,serial=9e5f"'
    samp_rate: samp_rate
    type: fc32
    vga: tx_vga_gain
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: rx_amp
    center_freq: freq + rx_freq_offset
    dev_args: '"driver=hackrf,serial=915f"'
    gain: rx_if_gain
    samp_rate: samp_rate
    type: fc32
    vga: rx_vga_gain
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [audio_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_1, '0']
- [rational_resampler_xxx_1, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
