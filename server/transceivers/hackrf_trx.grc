options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: no_gui
    id: hackrf_trx
    output_language: python
    title: HackRF Transceiver
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: cfo
  id: variable
  parameters:
    value: 435.4e6
  states: {}
- name: da
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: gfsk_freq_dev
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: lna
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: mode
  id: variable
  parameters:
    value: '1'
  states: {}
- name: pa
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: rx_amp
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: rx_decim1
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rx_decim2
  id: variable
  parameters:
    value: '125'
  states: {}
- name: rx_decim3
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_decim4
  id: variable
  parameters:
    value: '25'
  states: {}
- name: rx_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 0.75*(min(rx_samp_rate3,rx_samp_rate2)/2)
    gain: '1.0'
    samp_rate: rx_samp_rate5
    width: 0.75*(min(rx_samp_rate3,rx_samp_rate2)/2)
    win: window.WIN_HAMMING
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: rx_if_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_interp2
  id: variable
  parameters:
    value: '48'
  states: {}
- name: rx_samp_per_baud
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rx_samp_rate1
  id: variable
  parameters:
    value: rx_samp_per_baud*baud_rate
  states: {}
- name: rx_samp_rate2
  id: variable
  parameters:
    value: rx_decim1*rx_samp_rate1
  states: {}
- name: rx_samp_rate3
  id: variable
  parameters:
    value: rx_samp_rate2*rx_decim2/rx_interp2
  states: {}
- name: rx_samp_rate4
  id: variable
  parameters:
    value: rx_samp_rate3*rx_decim3
  states: {}
- name: rx_samp_rate5
  id: variable
  parameters:
    value: rx_samp_rate4*rx_decim4
  states: {}
- name: rx_vga_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: tx_amp
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: tx_baud_per_buf
  id: variable
  parameters:
    value: 2**9
  states: {}
- name: tx_buffer
  id: variable
  parameters:
    value: 2**17
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: tx_pwr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_samp_per_baud
  id: variable
  parameters:
    value: tx_buffer/tx_baud_per_buf
  states: {}
- name: tx_samp_rate1
  id: variable
  parameters:
    value: tx_samp_per_baud*baud_rate
  states: {}
- name: tx_vga_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: UTAT_HERON_esttc_deframer_0
  id: UTAT_HERON_esttc_deframer
  parameters:
    samp_rate: baud_rate
  states: {}
- name: UTAT_HERON_esttc_framer_0
  id: UTAT_HERON_esttc_framer
  parameters: {}
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '2'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: rx_samp_rate1
    max_dev: 5e3
    quad_rate: rx_samp_rate1
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: int(48e3)
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: int(48e3)
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch_threshold
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/heron/recordings/other_satellites/BDSAT-2-48k-2024-10-24-22-52-00.fc32
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: tx_freq-cfo
    sample_rate: tx_samp_rate1
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: rx_freq
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: tx_freq
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: int(mode >= 1)
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(mode >= 1)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 1 if mode == 3 else 0
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 1 if mode == 3 else 0
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: 0 if mode == 1 else 1
    type: byte
  states: {}
- name: blocks_selector_3
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: 0 if mode == 1 else 1
    type: byte
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 11*rx_samp_per_baud
    rolloff: '0.35'
    samps_per_sym: rx_samp_per_baud
    type: cc
    w: 2*math.pi/100
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: 0.00875 - 0.00875
    mu: '0.5'
    omega_relative_limit: 0.000375 - 0.000375
    samples_per_symbol: rx_samp_per_baud
    sensitivity: 2*pi*(gfsk_freq_dev)/rx_samp_rate1
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    do_unpack: 'False'
    samples_per_symbol: int(tx_samp_per_baud)
    sensitivity: 2*pi*(gfsk_freq_dev)/tx_samp_rate1
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x7F'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import time


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, baud_rate=9600, delay=0, extra=0):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PTT',
                  in_sig=None,
                  out_sig=None
              )

              self.baud_rate = baud_rate
              self.delay = delay
              self.extra = extra

              self.port_ptt = pmt.intern('ptt')
              self.port_tx_vga_gain = pmt.intern('tx_vga_gain')
              self.port_tx_amp = pmt.intern('tx_amp')
              self.port_da = pmt.intern('da')

              self.message_port_register_in(self.port_ptt)
              self.message_port_register_out(self.port_tx_amp)
              self.message_port_register_out(self.port_tx_vga_gain)
              self.message_port_register_out(self.port_da)

              self.set_msg_handler(self.port_ptt, self.ptt_handler)

          def ptt_handler(self, msg):
              try:
                  # req = pmt.to_bool(pmt.cdr(msg))
                  nbauds = pmt.length(pmt.cdr(msg))
                  tx_time = nbauds/self.baud_rate+self.extra

                  time.sleep(self.delay)
                  self.message_port_pub(self.port_da, pmt.cons(self.port_da, pmt.PMT_T))
                  self.message_port_pub(self.port_tx_vga_gain, pmt.cons(self.port_tx_vga_gain, pmt.from_long(47)))
                  self.message_port_pub(self.port_tx_amp, pmt.cons(self.port_tx_amp, pmt.PMT_T))

                  time.sleep(tx_time)
                  self.message_port_pub(self.port_da, pmt.cons(self.port_da, pmt.PMT_F))
                  self.message_port_pub(self.port_tx_vga_gain, pmt.cons(self.port_tx_vga_gain, pmt.from_long(0)))
                  self.message_port_pub(self.port_tx_amp, pmt.cons(self.port_tx_amp, pmt.PMT_F))
              except ValueError:
                  pass

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              return 0
    baud_rate: '9600'
    delay: '0'
    extra: '250e-3'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: rx_freq-cfo
    decim: rx_decim4
    samp_rate: rx_samp_rate5
    taps: rx_filter_taps
    type: ccc
  states: {}
- name: gpredict_MsgPairToVar_0_0_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: tx_amp
  states: {}
- name: gpredict_MsgPairToVar_0_1_0
  id: gpredict_MsgPairToVar
  parameters:
    target: tx_vga_gain
  states: {}
- name: gpredict_MsgPairToVar_0_1_1
  id: gpredict_MsgPairToVar
  parameters:
    target: da
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 0.0.0.0
    gpredict_port: gpredict_port
    verbose: 'False'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: gpredict port
    type: intx
    value: '52002'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.75*(min(rx_samp_rate3,rx_samp_rate2)/2)
    decim: rx_decim3
    gain: '1'
    samp_rate: rx_samp_rate4
    type: fir_filter_ccf
    width: 0.25*(min(rx_samp_rate3,rx_samp_rate2)/2)
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: (gfsk_freq_dev/2+baud_rate/2)*1.1
    decim: rx_decim1
    gain: '1'
    samp_rate: rx_samp_rate2
    type: fir_filter_ccf
    width: (gfsk_freq_dev/2+baud_rate/2)*0.2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: (gfsk_freq_dev/2+baud_rate/2)*1.1
    decim: '1'
    gain: '1'
    samp_rate: rx_samp_rate1
    type: fir_filter_ccf
    width: (gfsk_freq_dev/2+baud_rate/2)*0.2
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 48e3/tx_samp_rate1
    type: complex
  states: {}
- name: mmse_resampler_xx_1
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: rx_decim2/rx_interp2
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=9e5f"'
    bb_gain0: '0'
    clock_source0: external
    corr0: '1.5'
    freq0: cfo
    gain0: 14 if tx_amp else 0
    if_gain0: tx_vga_gain
    sample_rate: tx_samp_rate1
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=915f"'
    bb_gain0: rx_vga_gain
    clock_source0: external
    corr0: 1.5-1.5
    freq0: cfo+600
    gain0: 14 if rx_amp else 0
    gain_mode0: 'False'
    if_gain0: rx_if_gain
    sample_rate: rx_samp_rate4
    sync: sync
    type: fc32
  states: {state: disabled}
- name: output
  id: parameter
  parameters:
    label: Output IQ file
    type: str
    value: /dev/null
  states: {}
- name: pdu_add_system_time_0
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("Tx")
  states: {}
- name: pdu_add_system_time_1
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("Rx")
  states: {}
- name: pdu_add_system_time_1_0
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("Rx CRC FAIL")
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    comment: padding
    fn: 'lambda x: np.append(x, [np.uint8(1) if i%2 else np.uint8(0) for i in range(tx_baud_per_buf-((len(x))%tx_baud_per_buf))])'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_lambda_0_0
  id: pdu_pdu_lambda
  parameters:
    comment: padding
    fn: 'lambda x: np.append(x, [np.uint8(1) if i%2 else np.uint8(0) for i in range(tx_baud_per_buf+1)])'
    metadict: Uniform Vector
  states: {state: disabled}
- name: pdu_pdu_lambda_1
  id: pdu_pdu_lambda
  parameters:
    comment: unpack bits
    fn: 'lambda x: np.unpackbits(x)'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_lambda_2
  id: pdu_pdu_lambda
  parameters:
    comment: front padding
    fn: 'lambda x: np.append(30*(np.uint8(0x7E),), x)'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: selector
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: ax25
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: selector
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: selector
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: ax25
    type: byte
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '7'
    preamble_bytes: '40'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: rx_amp
    center_freq: cfo+800
    dev_args: '"driver=hackrf,serial=915f"'
    gain: rx_if_gain
    samp_rate: int(rx_samp_rate5)
    type: fc32
    vga: rx_vga_gain
  states: {}
- name: toptek_toptek_control_0
  id: toptek_toptek_control
  parameters:
    da: da
    lna: lna
    pa: pa
    serial_port: /dev/ttyAmplifier
    tx_pwr: tx_pwr
    verbose: 'True'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '8080'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://*:"+str(zmq_rx_bb)'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://*:"+str(zmq_rx_audio)'
    timeout: '100'
    type: float
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: '"tcp://*:"+str(zmq_tx_packet)'
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://*:"+str(zmq_rx_packet)'
    timeout: '100'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://*:"+str(zmq_tx_audio)'
    bind: 'True'
    timeout: '100'
    type: float
  states: {}
- name: zmq_rx_audio
  id: parameter
  parameters:
    label: RX audio
    type: intx
    value: '50493'
  states: {}
- name: zmq_rx_bb
  id: parameter
  parameters:
    label: RX baseband
    type: intx
    value: '52001'
  states: {}
- name: zmq_rx_packet
  id: parameter
  parameters:
    label: RX packets
    type: intx
    value: '50492'
  states: {}
- name: zmq_tx_audio
  id: parameter
  parameters:
    label: TX audio
    type: intx
    value: '50494'
  states: {}
- name: zmq_tx_packet
  id: parameter
  parameters:
    label: TX packets
    type: intx
    value: '50491'
  states: {}

connections:
- [UTAT_HERON_esttc_deframer_0, crc_fail, pdu_add_system_time_1_0, pdu]
- [UTAT_HERON_esttc_deframer_0, crc_ok, pdu_add_system_time_1, pdu]
- [UTAT_HERON_esttc_framer_0, pdu_out, pdu_pdu_lambda_2, pdu]
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_nbfm_rx_0, '0', zeromq_pub_sink_1, '0']
- [analog_nbfm_tx_0, '0', mmse_resampler_xx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_nbfm_rx_0, '0']
- [blocks_file_source_0, '0', blocks_selector_0, '0']
- [blocks_freqshift_cc_0, '0', osmosdr_sink_0, '0']
- [blocks_selector_0, '0', analog_pwr_squelch_xx_0, '0']
- [blocks_selector_0, '1', digital_gfsk_demod_0, '0']
- [blocks_selector_0_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_selector_1, '0', satellites_hdlc_deframer_0, '0']
- [blocks_selector_1_0, '0', satellites_nrzi_encode_0, '0']
- [blocks_selector_2, '0', UTAT_HERON_esttc_deframer_0, '0']
- [blocks_selector_2, '1', satellites_nrzi_decode_0, '0']
- [blocks_selector_3, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_selector_3, '1', pdu_tagged_stream_to_pdu_0_0, '0']
- [digital_descrambler_bb_0, '0', blocks_selector_1, '1']
- [digital_fll_band_edge_cc_0, '0', blocks_selector_0, '0']
- [digital_gfsk_demod_0, '0', blocks_selector_2, '0']
- [digital_gfsk_mod_0, '0', blocks_selector_0_0, '1']
- [digital_scrambler_bb_0, '0', blocks_selector_1_0, '1']
- [epy_block_1, da, gpredict_MsgPairToVar_0_1_1, inpair]
- [epy_block_1, tx_amp, gpredict_MsgPairToVar_0_0_0_0, inpair]
- [epy_block_1, tx_vga_gain, gpredict_MsgPairToVar_0_1_0, inpair]
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [gpredict_doppler_0, freq, blocks_msgpair_to_var_0, inpair]
- [gpredict_doppler_0, tx_freq, blocks_msgpair_to_var_1, inpair]
- [low_pass_filter_0, '0', mmse_resampler_xx_1, '0']
- [low_pass_filter_0_0, '0', low_pass_filter_0_0_0_1, '0']
- [low_pass_filter_0_0_0_1, '0', analog_agc_xx_0, '0']
- [low_pass_filter_0_0_0_1, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0_0_0_1, '0', zeromq_pub_sink_0, '0']
- [mmse_resampler_xx_0, '0', blocks_selector_0_0, '0']
- [mmse_resampler_xx_1, '0', low_pass_filter_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [pdu_add_system_time_0, pdu, blocks_message_debug_0, log]
- [pdu_add_system_time_1, pdu, blocks_message_debug_0, log]
- [pdu_add_system_time_1, pdu, zeromq_push_msg_sink_0, in]
- [pdu_add_system_time_1_0, pdu, blocks_message_debug_0, log]
- [pdu_add_system_time_1_0, pdu, zeromq_push_msg_sink_0, in]
- [pdu_pdu_lambda_0, pdu, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_lambda_0_0, pdu, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_lambda_1, pdu, epy_block_1, ptt]
- [pdu_pdu_lambda_1, pdu, pdu_pdu_lambda_0, pdu]
- [pdu_pdu_lambda_1, pdu, pdu_pdu_lambda_0_0, pdu]
- [pdu_pdu_lambda_2, pdu, pdu_pdu_lambda_1, pdu]
- [pdu_pdu_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_selector_3, '0']
- [pdu_pdu_to_tagged_stream_1_0, '0', blocks_selector_1_0, '0']
- [pdu_pdu_to_tagged_stream_1_0, '0', digital_scrambler_bb_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, UTAT_HERON_esttc_framer_0, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, satellites_hdlc_framer_0, in]
- [pdu_tagged_stream_to_pdu_1, pdus, epy_block_1, ptt]
- [pdu_tagged_stream_to_pdu_1, pdus, pdu_pdu_lambda_0, pdu]
- [pdu_tagged_stream_to_pdu_1, pdus, pdu_pdu_lambda_0_0, pdu]
- [satellites_hdlc_deframer_0, out, pdu_add_system_time_1, pdu]
- [satellites_hdlc_framer_0, out, pdu_pdu_to_tagged_stream_1_0, pdus]
- [satellites_nrzi_decode_0, '0', blocks_selector_1, '0']
- [satellites_nrzi_decode_0, '0', digital_descrambler_bb_0, '0']
- [satellites_nrzi_encode_0, '0', pdu_tagged_stream_to_pdu_1, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [zeromq_pull_msg_source_0, out, pdu_add_system_time_0, pdu]
- [zeromq_pull_msg_source_0, out, pdu_pdu_to_tagged_stream_1, pdus]
- [zeromq_sub_source_0, '0', analog_nbfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
