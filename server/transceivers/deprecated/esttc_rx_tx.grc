options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: no_gui
    id: esttc_rx_tx
    output_language: python
    title: ESTTC Rx/Tx
  states: {}

blocks:
- name: control_port
  id: variable
  parameters:
    value: base_port
  states: {}
- name: freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: front_padding_nbytes
  id: variable
  parameters:
    value: '10'
  states: {}
- name: gfsk_bps
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: gfsk_bt
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: gfsk_freq_dev
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: gfsk_mod_ind
  id: variable
  parameters:
    value: 2 * gfsk_freq_dev / gfsk_bps
  states: {}
- name: gfsk_samp_rate
  id: variable
  parameters:
    value: gfsk_sps * gfsk_bps
  states: {}
- name: gfsk_sensitivity
  id: variable
  parameters:
    value: 2*pi*gfsk_freq_dev/gfsk_samp_rate
  states: {}
- name: gfsk_sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: gpredict_port
  id: variable
  parameters:
    value: base_port+2
  states: {}
- name: rx_amp
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: rx_freq_offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: rx_if_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: rx_vga_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: stream_port
  id: variable
  parameters:
    value: base_port+1
  states: {}
- name: tx_amp
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: tx_vga_gain
  id: variable
  parameters:
    value: '47'
  states: {}
- name: UTAT_HERON_esttc_deframer_0
  id: UTAT_HERON_esttc_deframer
  parameters:
    samp_rate: gfsk_samp_rate
  states: {}
- name: UTAT_HERON_esttc_deframer_0_0
  id: UTAT_HERON_esttc_deframer
  parameters:
    samp_rate: gfsk_samp_rate
  states: {state: disabled}
- name: UTAT_HERON_esttc_framer_0
  id: UTAT_HERON_esttc_framer
  parameters: {}
  states: {}
- name: UTAT_HERON_tagged_stream_fixed_length_padder_0
  id: UTAT_HERON_tagged_stream_fixed_length_padder
  parameters:
    additional_symb_overflow: '5'
    filler: '0x01'
    final_buffer_len: 2**17
    final_samples_per_symbol: 8*samp_rate/gfsk_bps
    len_tag_key: packet_len
  states: {}
- name: UTAT_HERON_variable_filter_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: freq
  states: {}
- name: UTAT_HERON_variable_filter_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_freq_offset
  states: {}
- name: UTAT_HERON_variable_filter_0_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: squelch_threshold
  states: {state: disabled}
- name: UTAT_HERON_variable_filter_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_if_gain
  states: {}
- name: UTAT_HERON_variable_filter_1_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_vga_gain
  states: {}
- name: UTAT_HERON_variable_filter_1_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: volume
  states: {state: disabled}
- name: UTAT_HERON_variable_filter_1_0_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_amp
  states: {}
- name: UTAT_HERON_variable_filter_1_0_1_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: pa
  states: {}
- name: UTAT_HERON_variable_filter_1_0_1_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: da
  states: {}
- name: UTAT_HERON_variable_filter_1_0_1_0_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: lna
  states: {}
- name: UTAT_HERON_variable_filter_1_0_1_0_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: tx_pwr
  states: {}
- name: UTAT_HERON_variable_filter_1_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: tx_vga_gain
  states: {}
- name: UTAT_HERON_variable_filter_1_2
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: tx_amp
  states: {}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '10'
    rate: '625e-6'
    reference: '1.0'
    type: complex
  states: {}
- name: base_port
  id: parameter
  parameters:
    label: Base Port
    type: intx
    value: '52000'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: tx_freq-freq+rx_freq_offset
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    freq: rx_freq_offset + (freq-rx_freq)
    sample_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: rx_freq
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: tx_freq
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: front_padding_nbytes
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0xAA, 0xAA, 0xAA)
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '175e-3'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(gfsk_sps)
    sensitivity: gfsk_sensitivity
  states: {}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '175e-3'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(gfsk_sps)
    sensitivity: gfsk_sensitivity
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: gfsk_bt
    samples_per_symbol: int(gfsk_sps)
    sensitivity: gfsk_sensitivity
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport time\nimport sys\n\n# sys.path.append('/home/heron/toptek-control/python')\n# from toptek import Toptek\n\n\nSLEEPY_TIME = 0.05\n\nclass blk(gr.sync_block):\n    \"\"\"Emulates push-to-talk by switching Tx HackRF gain on when Tx message is registered\"\"\"\n\n    def __init__(self, baud_rate=9600, padding_nbytes=10, delay_s=0, extra_s=0):\n        gr.sync_block.__init__(\n            self,\n            name='PTT',\n            in_sig=None,\n            out_sig=None\n        )\n        self.baud_rate = baud_rate\n        self.padding_nbytes = padding_nbytes\n        self.delay = delay_s\n        self.extra = extra_s\n        self.message_port_register_in(pmt.intern('tx_mag'))\n        self.message_port_register_out(pmt.intern('tx_amp'))\n        self.message_port_register_out(pmt.intern('tx_vga_gain'))\n        self.message_port_register_out(pmt.intern('pa'))\n        self.message_port_register_out(pmt.intern('da'))\n        self.message_port_register_out(pmt.intern('lna'))\n        self.set_msg_handler(pmt.intern('tx_mag'), self.handle_msg)\n        self.message_port_pub(\n            pmt.intern('pa'),\n            pmt.cons(pmt.PMT_NIL, pmt.PMT_T))\n        self.message_port_pub(\n            pmt.intern('lna'),\n            pmt.cons(pmt.PMT_NIL, pmt.PMT_T))\n\n    def handle_msg(self, msg):\n        msg = pmt.cdr(msg)\n        msg = pmt.u8vector_elements(msg)\n        length = (len(msg)+self.padding_nbytes)*8\n        tx_time = length/self.baud_rate + self.extra\n        time.sleep(self.delay)\n        # self.amp.da_on()\n        self.message_port_pub(\n            pmt.intern('da'),\n            pmt.cons(pmt.PMT_NIL, pmt.PMT_T))\n        # self.message_port_pub(\n        #    pmt.intern(\"tx_amp\"),\n        #    pmt.cons(pmt.intern(\"tx_amp\"), pmt.PMT_T))\n        # self.message_port_pub(\n        #    pmt.intern(\"tx_vga_gain\"),\n        #    pmt.cons(pmt.intern(\"tx_vga_gain\"), pmt.to_pmt(47)))\n        time.sleep(tx_time)\n        self.message_port_pub(\n            pmt.intern('da'),\n            pmt.cons(pmt.PMT_NIL, pmt.PMT_F))\n        # self.amp.da_off()\n        #self.message_port_pub(\n        #    pmt.intern(\"tx_amp\"),\n        #    pmt.cons(pmt.intern(\"tx_amp\"), pmt.PMT_F))\n        #self.message_port_pub(\n        #    pmt.intern(\"tx_vga_gain\"),\n        #    pmt.cons(pmt.intern(\"tx_vga_gain\"), pmt.to_pmt(0)))\n\n    def work(self, input_items, output_items):\n        return 0\n"
    baud_rate: '9600'
    delay_s: '120e-3'
    extra_s: '50e-3'
    padding_nbytes: front_padding_nbytes-front_padding_nbytes
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import sys
      from gnuradio import gr
      import pmt

      sys.path.append('/home/heron/toptek-control/python')
      from toptek import Toptek

      class blk(gr.sync_block):
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, serial_port:str="/dev/ttyAmplifier"):
              gr.sync_block.__init__(
                  self,
                  name='Toptek Control',
                  in_sig=None,
                  out_sig=None
              )
              self.amp = Toptek(serial_port)
              self.message_port_register_in(pmt.intern('pa'))
              self.message_port_register_in(pmt.intern('da'))
              self.message_port_register_in(pmt.intern('lna'))
              self.message_port_register_in(pmt.intern('tx_pwr'))
              self.set_msg_handler(pmt.intern('pa'), self.pa_handler)
              self.set_msg_handler(pmt.intern('da'), self.da_handler)
              self.set_msg_handler(pmt.intern('lna'), self.lna_handler)
              self.set_msg_handler(pmt.intern('tx_pwr'), self.tx_pwr_handler)
              self.log = gr.logger(self.alias())
          
          def pa_handler(self, msg):
              try:
                  state = pmt.to_bool(pmt.cdr(msg))
                  if state:
                      self.amp.pa_on()
                  else:
                      self.amp.pa_off()
              except ValueError:
                  pass
          
          def da_handler(self, msg):
              try:
                  state = pmt.to_bool(pmt.cdr(msg))
                  if state:
                      self.amp.da_on()
                  else:
                      self.amp.da_off()
              except ValueError:
                  pass
          
          def lna_handler(self, msg):
              try:
                  state = pmt.to_bool(pmt.cdr(msg))
                  if state:
                      self.amp.lna_on()
                  else:
                      self.amp.lna_off()
              except ValueError:
                  pass
          
          def tx_pwr_handler(self, msg):
              try:
                  pwr = pmt.to_long(pmt.cdr(msg))
              except ValueError:
                  return
              try:
                  self.amp.set_tx_power(pwr)
                  self.log.info(f"tx power set: {pwr}")
              except (ValueError,RuntimeError) as e:
                  self.log.warn(f"{e}")
          

          def work(self, input_items, output_items):
              return 0
    serial_port: '''/dev/ttyAmplifier'''
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_MsgPairToVar_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_freq_offset
  states: {}
- name: gpredict_MsgPairToVar_0_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_vga_gain
  states: {}
- name: gpredict_MsgPairToVar_0_0_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: tx_amp
  states: {}
- name: gpredict_MsgPairToVar_0_1
  id: gpredict_MsgPairToVar
  parameters:
    target: squelch_threshold
  states: {state: disabled}
- name: gpredict_MsgPairToVar_0_1_0
  id: gpredict_MsgPairToVar
  parameters:
    target: tx_vga_gain
  states: {}
- name: gpredict_MsgPairToVar_0_1_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_amp
  states: {}
- name: gpredict_MsgPairToVar_0_2
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_if_gain
  states: {}
- name: gpredict_MsgPairToVar_0_2_0
  id: gpredict_MsgPairToVar
  parameters:
    target: volume
  states: {state: disabled}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 0.0.0.0
    gpredict_port: gpredict_port
    verbose: 'False'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '40'
    bandwidth: '20000000'
    buffer_size: 2**23
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(freq - rx_freq_offset)
    samplerate: int(samp_rate)
    type: fc32
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: 2**21
    filter_source: '''Auto'''
    frequency: int(freq + rx_freq_offset)
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '20'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '2'
    gain: '1'
    samp_rate: samp_rate/20
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: stream_port
    type: complex
  states: {}
- name: pdu_add_system_time_0
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("Tx")
  states: {}
- name: pdu_add_system_time_1
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("Rx")
  states: {}
- name: pdu_add_system_time_1_0
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("Rx CRC FAIL")
  states: {}
- name: pdu_add_system_time_1_0_0
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("Tx CRC FAIL")
  states: {state: disabled}
- name: pdu_add_system_time_1_1
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("Tx")
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '250'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '12'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: tx_amp
    center_freq: freq-rx_freq_offset
    dev_args: '"driver=hackrf,serial=9e5f,buffers=32"'
    samp_rate: samp_rate
    type: fc32
    vga: tx_vga_gain
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: rx_amp
    center_freq: freq + rx_freq_offset
    dev_args: '"driver=hackrf,serial=915f,buffers=32"'
    gain: rx_if_gain
    samp_rate: samp_rate
    type: fc32
    vga: rx_vga_gain
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://*:50491
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_3
  id: zeromq_pull_msg_source
  parameters:
    address: '"tcp://*:"+str(control_port)'
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://*:50492
    timeout: '100'
  states: {}

connections:
- [UTAT_HERON_esttc_deframer_0, crc_fail, pdu_add_system_time_1_0, pdu]
- [UTAT_HERON_esttc_deframer_0, crc_ok, pdu_add_system_time_1, pdu]
- [UTAT_HERON_esttc_deframer_0, crc_ok, zeromq_push_msg_sink_0, in]
- [UTAT_HERON_esttc_deframer_0_0, crc_fail, pdu_add_system_time_1_0_0, pdu]
- [UTAT_HERON_esttc_deframer_0_0, crc_ok, pdu_add_system_time_1_1, pdu]
- [UTAT_HERON_esttc_framer_0, pdu_out, epy_block_0, tx_mag]
- [UTAT_HERON_esttc_framer_0, pdu_out, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [UTAT_HERON_tagged_stream_fixed_length_padder_0, '0', digital_gfsk_mod_0, '0']
- [UTAT_HERON_variable_filter_0, out, blocks_msgpair_to_var_0, inpair]
- [UTAT_HERON_variable_filter_0, out, blocks_msgpair_to_var_1, inpair]
- [UTAT_HERON_variable_filter_0, out, gpredict_MsgPairToVar_0, inpair]
- [UTAT_HERON_variable_filter_0_0, out, gpredict_MsgPairToVar_0_0, inpair]
- [UTAT_HERON_variable_filter_0_0_0, out, gpredict_MsgPairToVar_0_1, inpair]
- [UTAT_HERON_variable_filter_1, out, gpredict_MsgPairToVar_0_2, inpair]
- [UTAT_HERON_variable_filter_1_0, out, gpredict_MsgPairToVar_0_0_0, inpair]
- [UTAT_HERON_variable_filter_1_0_0, out, gpredict_MsgPairToVar_0_2_0, inpair]
- [UTAT_HERON_variable_filter_1_0_1, out, gpredict_MsgPairToVar_0_1_0_0, inpair]
- [UTAT_HERON_variable_filter_1_0_1_0, out, epy_block_1, pa]
- [UTAT_HERON_variable_filter_1_0_1_0_0, out, epy_block_1, da]
- [UTAT_HERON_variable_filter_1_0_1_0_0_0, out, epy_block_1, lna]
- [UTAT_HERON_variable_filter_1_0_1_0_1, out, epy_block_1, tx_pwr]
- [UTAT_HERON_variable_filter_1_1, out, gpredict_MsgPairToVar_0_1_0, inpair]
- [UTAT_HERON_variable_filter_1_2, out, gpredict_MsgPairToVar_0_0_0_0, inpair]
- [analog_agc_xx_1, '0', digital_gfsk_demod_0, '0']
- [analog_agc_xx_1, '0', network_tcp_sink_0, '0']
- [blocks_freqshift_cc_0, '0', iio_pluto_sink_0, '0']
- [blocks_freqshift_cc_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_freqshift_cc_1, '0', low_pass_filter_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_tagged_stream_mux_0, '0', UTAT_HERON_tagged_stream_fixed_length_padder_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_gfsk_demod_0, '0', UTAT_HERON_esttc_deframer_0, '0']
- [digital_gfsk_demod_0_0, '0', UTAT_HERON_esttc_deframer_0_0, '0']
- [digital_gfsk_mod_0, '0', digital_gfsk_demod_0_0, '0']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_0, da, epy_block_1, da]
- [epy_block_0, lna, epy_block_1, lna]
- [epy_block_0, pa, epy_block_1, pa]
- [epy_block_0, tx_amp, gpredict_MsgPairToVar_0_0_0_0, inpair]
- [epy_block_0, tx_vga_gain, gpredict_MsgPairToVar_0_1_0, inpair]
- [gpredict_doppler_0, freq, blocks_msgpair_to_var_0, inpair]
- [gpredict_doppler_0, tx_freq, blocks_msgpair_to_var_1, inpair]
- [iio_pluto_source_0, '0', blocks_freqshift_cc_1, '0']
- [low_pass_filter_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_1, '0']
- [pdu_add_system_time_0, pdu, blocks_message_debug_0, print]
- [pdu_add_system_time_1, pdu, blocks_message_debug_0, print]
- [pdu_add_system_time_1_0, pdu, blocks_message_debug_0, print]
- [pdu_add_system_time_1_0_0, pdu, blocks_message_debug_0, print]
- [pdu_add_system_time_1_1, pdu, blocks_message_debug_0, print]
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [rational_resampler_xxx_0, '0', blocks_freqshift_cc_0, '0']
- [rational_resampler_xxx_1, '0', analog_agc_xx_1, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_1, '0']
- [zeromq_pull_msg_source_0, out, UTAT_HERON_esttc_framer_0, pdu_in]
- [zeromq_pull_msg_source_0, out, pdu_add_system_time_0, pdu]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_0, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_0_0, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_0_0_0, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_1, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_1_0, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_1_0_0, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_1_0_1, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_1_0_1_0, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_1_0_1_0_0, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_1_0_1_0_0_0, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_1_0_1_0_1, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_1_1, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_1_2, in]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
