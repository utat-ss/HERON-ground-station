options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: no_gui
    id: pluto_cw_trx
    output_language: python
    title: Pluto ESTTC Transceiver
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: front_padding_nbytes
  id: variable
  parameters:
    value: '10'
  states: {}
- name: gfsk_bps
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: gfsk_bt
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: gfsk_freq_dev
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: gfsk_mod_ind
  id: variable
  parameters:
    value: 2 * gfsk_freq_dev / gfsk_bps
  states: {}
- name: gfsk_samp_rate
  id: variable
  parameters:
    value: gfsk_sps * gfsk_bps
  states: {}
- name: gfsk_sensitivity
  id: variable
  parameters:
    value: 2*pi*gfsk_freq_dev/gfsk_samp_rate
  states: {}
- name: gfsk_sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '71'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '89.75'
  states: {}
- name: UTAT_HERON_variable_filter_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: freq
  states: {}
- name: UTAT_HERON_variable_filter_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: freq_offset
  states: {}
- name: UTAT_HERON_variable_filter_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_gain
  states: {}
- name: UTAT_HERON_variable_filter_1_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: tx_gain
  states: {}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '10'
    rate: '625e-6'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: int(gfsk_samp_rate)
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: int(gfsk_samp_rate)
    tau: '75e-6'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: tx_freq-freq+freq_offset
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    freq: freq_offset + (freq-rx_freq)
    sample_rate: samp_rate
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: rx_freq
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: tx_freq
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_MsgPairToVar_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq_offset
  states: {}
- name: gpredict_MsgPairToVar_0_1_0
  id: gpredict_MsgPairToVar
  parameters:
    target: tx_gain
  states: {}
- name: gpredict_MsgPairToVar_0_2
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_gain
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 0.0.0.0
    gpredict_port: gpredict_port
    verbose: 'False'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: gpredict port
    type: intx
    value: '52002'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: 89.75-tx_gain
    bandwidth: '20000000'
    buffer_size: 2**17
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(freq - freq_offset + 4e3)
    samplerate: int(samp_rate)
    type: fc32
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: 2**17
    filter_source: '''Auto'''
    frequency: int(freq + freq_offset + 4e3)
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '4'
    gain: '1'
    samp_rate: samp_rate/10
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: output
  id: parameter
  parameters:
    label: Output IQ file
    type: str
    value: /dev/null
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '250'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '12'
    type: ccc
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_baseband_stream
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pull_msg_source_0_3
  id: zeromq_pull_msg_source
  parameters:
    address: zmq_control
    bind: 'True'
    timeout: '100'
  states: {}
- name: zmq_baseband_stream
  id: parameter
  parameters:
    label: ZMQ Baseband Stream
    type: str
    value: tcp://*:52001
  states: {}
- name: zmq_control
  id: parameter
  parameters:
    label: ZMQ Control
    type: str
    value: tcp://*:52000
  states: {}
- name: zmq_rx
  id: parameter
  parameters:
    label: ZMQ Rx location
    type: str
    value: tcp://*:50492
  states: {}
- name: zmq_tx
  id: parameter
  parameters:
    label: ZMQ Tx location
    type: str
    value: tcp://*:50491
  states: {}

connections:
- [UTAT_HERON_variable_filter_0, out, blocks_msgpair_to_var_0, inpair]
- [UTAT_HERON_variable_filter_0, out, blocks_msgpair_to_var_1, inpair]
- [UTAT_HERON_variable_filter_0, out, gpredict_MsgPairToVar_0, inpair]
- [UTAT_HERON_variable_filter_0_0, out, gpredict_MsgPairToVar_0_0, inpair]
- [UTAT_HERON_variable_filter_1, out, gpredict_MsgPairToVar_0_2, inpair]
- [UTAT_HERON_variable_filter_1_1, out, gpredict_MsgPairToVar_0_1_0, inpair]
- [analog_agc_xx_1, '0', blocks_file_sink_0, '0']
- [analog_agc_xx_1, '0', zeromq_pub_sink_0, '0']
- [analog_const_source_x_0, '0', analog_nbfm_tx_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_freqshift_cc_0, '0', iio_pluto_sink_0, '0']
- [blocks_freqshift_cc_1, '0', low_pass_filter_0, '0']
- [gpredict_doppler_0, freq, blocks_msgpair_to_var_0, inpair]
- [gpredict_doppler_0, tx_freq, blocks_msgpair_to_var_1, inpair]
- [iio_pluto_source_0, '0', blocks_freqshift_cc_1, '0']
- [low_pass_filter_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_freqshift_cc_0, '0']
- [rational_resampler_xxx_1, '0', analog_agc_xx_1, '0']
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_0, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_0_0, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_1, in]
- [zeromq_pull_msg_source_0_3, out, UTAT_HERON_variable_filter_1_1, in]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
