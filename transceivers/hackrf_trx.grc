options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: no_gui
    id: hackrf_trx
    output_language: python
    title: HackRF Transceiver
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: cfo
  id: variable
  parameters:
    value: 435.4e6
  states: {}
- name: da
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: gfsk_freq_dev
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: lna
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pa
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: rx_amp
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: rx_decim1
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rx_decim2
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rx_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 0.75*(rx_samp_rate2/2)
    gain: '1.0'
    samp_rate: rx_samp_rate3
    width: 0.25*(rx_samp_rate2/2)
    win: window.WIN_HAMMING
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: rx_if_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_samp_per_baud
  id: variable
  parameters:
    value: '5'
  states: {}
- name: rx_samp_rate1
  id: variable
  parameters:
    value: rx_samp_per_baud*baud_rate
  states: {}
- name: rx_samp_rate2
  id: variable
  parameters:
    value: rx_decim1*rx_samp_rate1
  states: {}
- name: rx_samp_rate3
  id: variable
  parameters:
    value: rx_decim2*rx_samp_rate2
  states: {}
- name: rx_vga_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_amp
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: tx_baud_per_buf
  id: variable
  parameters:
    value: 2**9
  states: {}
- name: tx_buffer
  id: variable
  parameters:
    value: 2**17
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: tx_pwr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_samp_per_baud
  id: variable
  parameters:
    value: tx_buffer/tx_baud_per_buf
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: tx_samp_per_baud*baud_rate
  states: {}
- name: tx_vga_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: UTAT_HERON_esttc_deframer_0
  id: UTAT_HERON_esttc_deframer
  parameters:
    samp_rate: baud_rate
  states: {}
- name: UTAT_HERON_esttc_framer_0
  id: UTAT_HERON_esttc_framer
  parameters: {}
  states: {}
- name: UTAT_HERON_variable_filter_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: freq
  states: {state: disabled}
- name: UTAT_HERON_variable_filter_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: cfo
  states: {state: disabled}
- name: UTAT_HERON_variable_filter_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_if_gain
  states: {state: disabled}
- name: UTAT_HERON_variable_filter_1_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_vga_gain
  states: {state: disabled}
- name: UTAT_HERON_variable_filter_1_0_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_amp
  states: {state: disabled}
- name: UTAT_HERON_variable_filter_1_0_1_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: pa
  states: {state: disabled}
- name: UTAT_HERON_variable_filter_1_0_1_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: da
  states: {state: disabled}
- name: UTAT_HERON_variable_filter_1_0_1_0_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: lna
  states: {state: disabled}
- name: UTAT_HERON_variable_filter_1_0_1_0_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: tx_pwr
  states: {state: disabled}
- name: UTAT_HERON_variable_filter_1_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: tx_vga_gain
  states: {state: disabled}
- name: UTAT_HERON_variable_filter_1_2
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: tx_amp
  states: {state: disabled}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '10'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: tx_freq-cfo
    sample_rate: tx_samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: rx_freq
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: tx_freq
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: tx_samp_per_baud
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: tx_samp_rate
    type: complex
  states: {state: disabled}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'True'
    length_tag_name: '"packet_len"'
    post_padding: int(tx_samp_per_baud)
    pre_padding: int(tx_samp_per_baud)
    type: complex
    window: firdes.window(window.WIN_HANN, int(tx_samp_per_baud), 0)
  states: {state: disabled}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '80'
    rolloff: '0.35'
    samps_per_sym: rx_samp_rate2/baud_rate
    type: cc
    w: 2*math.pi/(rx_samp_rate2/baud_rate)/20
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.2'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: rx_samp_per_baud
    sensitivity: 2*pi*gfsk_freq_dev/rx_samp_rate1
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    do_unpack: 'False'
    samples_per_symbol: int(tx_samp_per_baud)
    sensitivity: 2*pi*gfsk_freq_dev/tx_samp_rate
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Shout Woo Hoo when samples are reached"""

          def __init__(self, samples=2**17):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Woo Hoo',
                  in_sig=[np.complex64],
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern('out'))
              self.samps = samples
              self.n = 0
              self.done = False

          def work(self, input_items, output_items):
              in0 = input_items[0]
              if not self.done:
                  self.n += len(in0)
                  if self.n >= self.samps:
                      self.message_port_pub(pmt.intern('out'), pmt.intern('Woooooooo Hooooooo! ' + str(self.n)))
                      self.done = True
              self.consume(0, len(in0))
              return 0
    samples: tx_buffer
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import time


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, baud_rate=9600, delay=0, extra=0):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PTT',
                  in_sig=None,
                  out_sig=None
              )

              self.baud_rate = baud_rate
              self.delay = delay
              self.extra = extra

              self.port_ptt = pmt.intern('ptt')
              self.port_tx_vga_gain = pmt.intern('tx_vga_gain')
              self.port_tx_amp = pmt.intern('tx_amp')
              self.port_da = pmt.intern('da')

              self.message_port_register_in(self.port_ptt)
              self.message_port_register_out(self.port_tx_amp)
              self.message_port_register_out(self.port_tx_vga_gain)
              self.message_port_register_out(self.port_da)

              self.set_msg_handler(self.port_ptt, self.ptt_handler)

          def ptt_handler(self, msg):
              try:
                  # req = pmt.to_bool(pmt.cdr(msg))
                  nbauds = pmt.length(pmt.cdr(msg))
                  tx_time = nbauds/self.baud_rate+self.extra

                  time.sleep(self.delay)
                  self.message_port_pub(self.port_da, pmt.cons(self.port_da, pmt.PMT_T))
                  self.message_port_pub(self.port_tx_vga_gain, pmt.cons(self.port_tx_vga_gain, pmt.from_long(47)))
                  self.message_port_pub(self.port_tx_amp, pmt.cons(self.port_tx_amp, pmt.PMT_T))

                  time.sleep(tx_time)
                  self.message_port_pub(self.port_da, pmt.cons(self.port_da, pmt.PMT_F))
                  self.message_port_pub(self.port_tx_vga_gain, pmt.cons(self.port_tx_vga_gain, pmt.from_long(0)))
                  self.message_port_pub(self.port_tx_amp, pmt.cons(self.port_tx_amp, pmt.PMT_F))
              except ValueError:
                  pass

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              return 0
    baud_rate: '9600'
    delay: '0'
    extra: '230e-3'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: rx_freq-cfo
    decim: rx_decim2
    samp_rate: rx_samp_rate3
    taps: rx_filter_taps
    type: ccc
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {state: disabled}
- name: gpredict_MsgPairToVar_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: cfo
  states: {state: disabled}
- name: gpredict_MsgPairToVar_0_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_vga_gain
  states: {state: disabled}
- name: gpredict_MsgPairToVar_0_0_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: tx_amp
  states: {}
- name: gpredict_MsgPairToVar_0_1
  id: gpredict_MsgPairToVar
  parameters:
    target: pa
  states: {state: disabled}
- name: gpredict_MsgPairToVar_0_1_0
  id: gpredict_MsgPairToVar
  parameters:
    target: tx_vga_gain
  states: {}
- name: gpredict_MsgPairToVar_0_1_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_amp
  states: {state: disabled}
- name: gpredict_MsgPairToVar_0_1_1
  id: gpredict_MsgPairToVar
  parameters:
    target: da
  states: {}
- name: gpredict_MsgPairToVar_0_1_2
  id: gpredict_MsgPairToVar
  parameters:
    target: lna
  states: {state: disabled}
- name: gpredict_MsgPairToVar_0_1_3
  id: gpredict_MsgPairToVar
  parameters:
    target: tx_pwr
  states: {state: disabled}
- name: gpredict_MsgPairToVar_0_2
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_if_gain
  states: {state: disabled}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 0.0.0.0
    gpredict_port: gpredict_port
    verbose: 'False'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: gpredict port
    type: intx
    value: '52002'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: (gfsk_freq_dev+baud_rate/2)
    decim: rx_decim1
    gain: '1'
    samp_rate: rx_samp_rate2
    type: fir_filter_ccf
    width: (gfsk_freq_dev+baud_rate/2)*0.1
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=9e5f"'
    bb_gain0: '0'
    clock_source0: external
    freq0: cfo
    gain0: 14 if tx_amp else 0
    if_gain0: tx_vga_gain
    sample_rate: tx_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=915f"'
    bb_gain0: rx_vga_gain
    clock_source0: external
    freq0: cfo
    gain0: 14 if rx_amp else 0
    gain_mode0: 'False'
    if_gain0: rx_if_gain
    sample_rate: rx_samp_rate3
    sync: sync
    type: fc32
  states: {}
- name: output
  id: parameter
  parameters:
    label: Output IQ file
    type: str
    value: /dev/null
  states: {}
- name: pdu_add_system_time_0
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("Tx")
  states: {}
- name: pdu_add_system_time_1
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("Rx")
  states: {}
- name: pdu_add_system_time_1_0
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("Rx CRC FAIL")
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    comment: padding
    fn: 'lambda x: np.append(x, [np.uint8(1) if i%2 else np.uint8(0) for i in range(tx_baud_per_buf-((len(x))%tx_baud_per_buf))])'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_lambda_1
  id: pdu_pdu_lambda
  parameters:
    comment: unpack bits
    fn: 'lambda x: np.unpackbits(x)'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_lambda_2
  id: pdu_pdu_lambda
  parameters:
    comment: front padding
    fn: 'lambda x: np.append(30*(np.uint8(0x7E),), x)'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: toptek_toptek_control_0
  id: toptek_toptek_control
  parameters:
    da: da
    lna: lna
    pa: pa
    serial_port: /dev/ttyAmplifier
    tx_pwr: tx_pwr
    verbose: 'True'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '8080'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_baseband_stream
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: zmq_tx
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: zmq_rx
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: zmq_control
    bind: 'True'
    timeout: '100'
  states: {state: disabled}
- name: zmq_baseband_stream
  id: parameter
  parameters:
    label: ZMQ Baseband Stream
    type: str
    value: tcp://*:52001
  states: {}
- name: zmq_control
  id: parameter
  parameters:
    label: ZMQ Control
    type: str
    value: tcp://*:52000
  states: {}
- name: zmq_rx
  id: parameter
  parameters:
    label: ZMQ Rx location
    type: str
    value: tcp://*:50492
  states: {}
- name: zmq_tx
  id: parameter
  parameters:
    label: ZMQ Tx location
    type: str
    value: tcp://*:50491
  states: {}

connections:
- [UTAT_HERON_esttc_deframer_0, crc_fail, pdu_add_system_time_1_0, pdu]
- [UTAT_HERON_esttc_deframer_0, crc_ok, pdu_add_system_time_1, pdu]
- [UTAT_HERON_esttc_framer_0, pdu_out, pdu_pdu_lambda_2, pdu]
- [UTAT_HERON_variable_filter_0, out, blocks_msgpair_to_var_0, inpair]
- [UTAT_HERON_variable_filter_0, out, blocks_msgpair_to_var_1, inpair]
- [UTAT_HERON_variable_filter_0, out, gpredict_MsgPairToVar_0, inpair]
- [UTAT_HERON_variable_filter_0_0, out, gpredict_MsgPairToVar_0_0, inpair]
- [UTAT_HERON_variable_filter_1, out, gpredict_MsgPairToVar_0_2, inpair]
- [UTAT_HERON_variable_filter_1_0, out, gpredict_MsgPairToVar_0_0_0, inpair]
- [UTAT_HERON_variable_filter_1_0_1, out, gpredict_MsgPairToVar_0_1_0_0, inpair]
- [UTAT_HERON_variable_filter_1_0_1_0, out, gpredict_MsgPairToVar_0_1, inpair]
- [UTAT_HERON_variable_filter_1_0_1_0_0, out, gpredict_MsgPairToVar_0_1_1, inpair]
- [UTAT_HERON_variable_filter_1_0_1_0_0_0, out, gpredict_MsgPairToVar_0_1_2, inpair]
- [UTAT_HERON_variable_filter_1_0_1_0_1, out, gpredict_MsgPairToVar_0_1_3, inpair]
- [UTAT_HERON_variable_filter_1_1, out, gpredict_MsgPairToVar_0_1_0, inpair]
- [UTAT_HERON_variable_filter_1_2, out, gpredict_MsgPairToVar_0_0_0_0, inpair]
- [analog_agc_xx_1, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_freqshift_cc_0, '0', osmosdr_sink_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', digital_burst_shaper_xx_0, '0']
- [digital_burst_shaper_xx_0, '0', blocks_freqshift_cc_0, '0']
- [digital_burst_shaper_xx_0, '0', blocks_tag_debug_0, '0']
- [digital_burst_shaper_xx_0, '0', blocks_tag_gate_0, '0']
- [digital_burst_shaper_xx_0, '0', blocks_throttle2_0, '0']
- [digital_burst_shaper_xx_0, '0', epy_block_0, '0']
- [digital_fll_band_edge_cc_0, '0', low_pass_filter_0_0, '0']
- [digital_gfsk_demod_0, '0', UTAT_HERON_esttc_deframer_0, '0']
- [digital_gfsk_mod_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [epy_block_0, out, blocks_message_debug_0, log]
- [epy_block_1, da, gpredict_MsgPairToVar_0_1_1, inpair]
- [epy_block_1, tx_amp, gpredict_MsgPairToVar_0_0_0_0, inpair]
- [epy_block_1, tx_vga_gain, gpredict_MsgPairToVar_0_1_0, inpair]
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0_0, '0']
- [gpredict_doppler_0, freq, blocks_msgpair_to_var_0, inpair]
- [gpredict_doppler_0, tx_freq, blocks_msgpair_to_var_1, inpair]
- [low_pass_filter_0_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0_0, '0', digital_gfsk_demod_0, '0']
- [low_pass_filter_0_0, '0', zeromq_pub_sink_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [pdu_add_system_time_0, pdu, blocks_message_debug_0, log]
- [pdu_add_system_time_1, pdu, blocks_message_debug_0, log]
- [pdu_add_system_time_1, pdu, zeromq_push_msg_sink_0, in]
- [pdu_add_system_time_1_0, pdu, blocks_message_debug_0, log]
- [pdu_add_system_time_1_0, pdu, zeromq_push_msg_sink_0, in]
- [pdu_pdu_lambda_0, pdu, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_lambda_1, pdu, epy_block_1, ptt]
- [pdu_pdu_lambda_1, pdu, pdu_pdu_lambda_0, pdu]
- [pdu_pdu_lambda_2, pdu, pdu_pdu_lambda_1, pdu]
- [pdu_pdu_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [zeromq_pull_msg_source_0, out, UTAT_HERON_esttc_framer_0, pdu_in]
- [zeromq_pull_msg_source_0, out, pdu_add_system_time_0, pdu]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_0, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_0_0, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_0, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_0_1, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_0_1_0, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_0_1_0_0, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_0_1_0_0_0, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_0_1_0_1, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_1, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_2, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
