options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: no_gui
    id: hackrf_nbfm_trx
    output_language: python
    title: HackRF NBFM Transceiver
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: rx_amp
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: rx_decim1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_decim2
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rx_decim3
  id: variable
  parameters:
    value: '25'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: rx_if_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_samp_rate1
  id: variable
  parameters:
    value: rx_decim1*audio_rate
  states: {}
- name: rx_samp_rate2
  id: variable
  parameters:
    value: rx_decim2*rx_samp_rate1
  states: {}
- name: rx_samp_rate3
  id: variable
  parameters:
    value: rx_decim3*rx_samp_rate2
  states: {}
- name: rx_vga_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: tx_amp
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: tx_interp1
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_interp2
  id: variable
  parameters:
    value: '10'
  states: {}
- name: tx_samp_rate1
  id: variable
  parameters:
    value: tx_interp1*audio_rate
  states: {}
- name: tx_samp_rate2
  id: variable
  parameters:
    value: tx_interp2*tx_samp_rate1
  states: {}
- name: tx_vga_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: UTAT_HERON_variable_filter_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: freq
  states: {}
- name: UTAT_HERON_variable_filter_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: freq_offset
  states: {}
- name: UTAT_HERON_variable_filter_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_if_gain
  states: {}
- name: UTAT_HERON_variable_filter_1_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_vga_gain
  states: {}
- name: UTAT_HERON_variable_filter_1_0_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_amp
  states: {}
- name: UTAT_HERON_variable_filter_1_0_1_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: pa
  states: {}
- name: UTAT_HERON_variable_filter_1_0_1_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: da
  states: {}
- name: UTAT_HERON_variable_filter_1_0_1_0_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: lna
  states: {}
- name: UTAT_HERON_variable_filter_1_0_1_0_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: tx_pwr
  states: {}
- name: UTAT_HERON_variable_filter_1_0_1_0_2
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: ptt
  states: {}
- name: UTAT_HERON_variable_filter_1_0_1_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: squelch_threshold
  states: {}
- name: UTAT_HERON_variable_filter_1_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: tx_vga_gain
  states: {}
- name: UTAT_HERON_variable_filter_1_2
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: tx_amp
  states: {}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '10'
    rate: '625e-6'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: rx_samp_rate1
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_rate*tx_interp1
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch_threshold
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: tx_freq-freq+freq_offset
    sample_rate: tx_samp_rate2
  states: {}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    freq: freq_offset + (freq-rx_freq)
    sample_rate: rx_samp_rate3
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: rx_freq
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: tx_freq
  states: {}
- name: blocks_msgpair_to_var_2
  id: blocks_msgpair_to_var
  parameters:
    target: squelch_threshold
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_MsgPairToVar_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq_offset
  states: {}
- name: gpredict_MsgPairToVar_0_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_vga_gain
  states: {}
- name: gpredict_MsgPairToVar_0_0_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: tx_amp
  states: {}
- name: gpredict_MsgPairToVar_0_1_0
  id: gpredict_MsgPairToVar
  parameters:
    target: tx_vga_gain
  states: {}
- name: gpredict_MsgPairToVar_0_1_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_amp
  states: {}
- name: gpredict_MsgPairToVar_0_2
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_if_gain
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 0.0.0.0
    gpredict_port: gpredict_port
    verbose: 'False'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: gpredict port
    type: intx
    value: '52002'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.75*(rx_samp_rate2/2)
    decim: rx_decim3
    gain: '1'
    samp_rate: rx_samp_rate3
    type: fir_filter_ccf
    width: 0.25*(rx_samp_rate2/2)
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: rx_decim2
    gain: '1'
    samp_rate: rx_samp_rate2
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=9e5f"'
    bb_gain0: '0'
    clock_source0: external
    freq0: freq-freq_offset
    gain0: 14 if tx_amp else 0
    if_gain0: tx_vga_gain
    sample_rate: tx_samp_rate2
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=915f"'
    bb_gain0: rx_vga_gain
    clock_source0: external
    freq0: freq + freq_offset
    gain0: 14 if rx_amp else 0
    gain_mode0: 'False'
    if_gain0: rx_if_gain
    sample_rate: rx_samp_rate3
    sync: sync
    type: fc32
  states: {}
- name: output
  id: parameter
  parameters:
    label: Output IQ file
    type: str
    value: /dev/null
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: tx_interp2
    type: ccc
  states: {}
- name: toptek_toptek_control_0
  id: toptek_toptek_control
  parameters:
    da: 'False'
    lna: 'False'
    pa: 'False'
    serial_port: /dev/ttyAmplifier
    tx_pwr: '0'
    verbose: 'True'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_baseband_stream
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: zmq_rx
    timeout: '100'
    type: float
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: zmq_tx
    bind: 'True'
    timeout: '100'
    type: float
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: zmq_control
    bind: 'True'
    timeout: '100'
  states: {}
- name: zmq_baseband_stream
  id: parameter
  parameters:
    label: ZMQ Baseband Stream
    type: str
    value: tcp://*:52001
  states: {}
- name: zmq_control
  id: parameter
  parameters:
    label: ZMQ Control
    type: str
    value: tcp://*:52000
  states: {}
- name: zmq_rx
  id: parameter
  parameters:
    label: ZMQ Rx location
    type: str
    value: tcp://*:50492
  states: {}
- name: zmq_tx
  id: parameter
  parameters:
    label: ZMQ Tx location
    type: str
    value: tcp://*:50491
  states: {}

connections:
- [UTAT_HERON_variable_filter_0, out, blocks_msgpair_to_var_0, inpair]
- [UTAT_HERON_variable_filter_0, out, blocks_msgpair_to_var_1, inpair]
- [UTAT_HERON_variable_filter_0, out, gpredict_MsgPairToVar_0, inpair]
- [UTAT_HERON_variable_filter_0_0, out, gpredict_MsgPairToVar_0_0, inpair]
- [UTAT_HERON_variable_filter_1, out, gpredict_MsgPairToVar_0_2, inpair]
- [UTAT_HERON_variable_filter_1_0, out, gpredict_MsgPairToVar_0_0_0, inpair]
- [UTAT_HERON_variable_filter_1_0_1, out, gpredict_MsgPairToVar_0_1_0_0, inpair]
- [UTAT_HERON_variable_filter_1_0_1_0, out, toptek_toptek_control_0, pa]
- [UTAT_HERON_variable_filter_1_0_1_0_0, out, toptek_toptek_control_0, da]
- [UTAT_HERON_variable_filter_1_0_1_0_0_0, out, toptek_toptek_control_0, lna]
- [UTAT_HERON_variable_filter_1_0_1_0_1, out, toptek_toptek_control_0, tx_pwr]
- [UTAT_HERON_variable_filter_1_0_1_0_2, out, toptek_toptek_control_0, ptt]
- [UTAT_HERON_variable_filter_1_0_1_1, out, blocks_msgpair_to_var_2, inpair]
- [UTAT_HERON_variable_filter_1_1, out, gpredict_MsgPairToVar_0_1_0, inpair]
- [UTAT_HERON_variable_filter_1_2, out, gpredict_MsgPairToVar_0_0_0_0, inpair]
- [analog_nbfm_rx_0, '0', zeromq_pub_sink_1, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_nbfm_rx_0, '0']
- [blocks_freqshift_cc_0, '0', osmosdr_sink_0, '0']
- [blocks_freqshift_cc_1, '0', low_pass_filter_0, '0']
- [gpredict_doppler_0, freq, blocks_msgpair_to_var_0, inpair]
- [gpredict_doppler_0, tx_freq, blocks_msgpair_to_var_1, inpair]
- [low_pass_filter_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', analog_agc_xx_1, '0']
- [low_pass_filter_0_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0_0, '0', zeromq_pub_sink_0, '0']
- [osmosdr_source_0, '0', blocks_freqshift_cc_1, '0']
- [rational_resampler_xxx_0, '0', blocks_freqshift_cc_0, '0']
- [zeromq_pull_source_0, '0', analog_nbfm_tx_0, '0']
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_0, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_0_0, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_0, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_0_1, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_0_1_0, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_0_1_0_0, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_0_1_0_0_0, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_0_1_0_1, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_0_1_0_2, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_0_1_1, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_1, in]
- [zeromq_sub_msg_source_0, out, UTAT_HERON_variable_filter_1_2, in]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
