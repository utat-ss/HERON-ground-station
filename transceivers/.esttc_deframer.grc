options:
  parameters:
    author: Swarnava Ghosh
    category: '[UTAT]'
    copyright: University of Toronto Aerospace Team
    description: Already implemented in C++! Check HERON-gr-utat repository.
    generate_options: hb
    id: ESTTC_Deframer_GRC
    output_language: python
    title: ESTTC Deframer GRC
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''101010101010101010101010101010101010101001111110'''
  states: {}
- name: hdr_format
  id: UTAT_HERON_header_format_esttc
  parameters:
    access_code: access_code
    bps: '1'
    threshold: '3'
    trailer_nbits: '16'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1/8
    lengthtagname: '"payload symbols"'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: access_code[8:]
    tagname: time_est
    threshold: '0'
    type: byte
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    discard_crc: 'True'
    final_xor: '0x0000'
    initial_value: '0xFFFF'
    input_reflected: 'False'
    num_bits: '16'
    poly: '0x1021'
    result_reflected: 'False'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '8'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"payload symbols"'
    output_symbols: 'False'
    samp_rate: samp_rate
    special_tags: '[]'
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"time_est"'
    type: byte
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, skip_bytes=0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Prepend Length',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.skip_bytes = skip_bytes\n        self.message_port_register_in(pmt.intern('pdu_in'))\n        self.message_port_register_out(pmt.intern('pdu_out'))\n        self.set_msg_handler(pmt.intern('pdu_in'), self.prepend_length)\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        return 0\n    \n    def prepend_length(self, pdu):\n        data = pmt.u8vector_elements(pmt.cdr(pdu))\n        length = len(data)\n        data = [length-self.skip_bytes] + data\n        data = pmt.init_u8vector(len(data), data)\n        pdu = pmt.cons(pmt.car(pdu), data)\n        self.message_port_pub(pmt.intern('pdu_out'), pdu)\n\n    \n\n"
    skip_bytes: '2'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: crc_ok
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: crc_fail
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_2_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"payload symbols"'
    type: byte
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 48e3
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pdu_tagged_stream_to_pdu_2_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', digital_header_payload_demux_0, '0']
- [digital_crc_check_0_0, fail, pad_sink_1, in]
- [digital_crc_check_0_0, ok, pad_sink_0, in]
- [digital_header_payload_demux_0, '0', digital_protocol_parser_b_0, '0']
- [digital_header_payload_demux_0, '1', blocks_repack_bits_bb_0, '0']
- [digital_protocol_parser_b_0, info, digital_header_payload_demux_0, header_data]
- [epy_block_1_0, pdu_out, digital_crc_check_0_0, in]
- [pad_source_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [pdu_tagged_stream_to_pdu_2_0, pdus, epy_block_1_0, pdu_in]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
