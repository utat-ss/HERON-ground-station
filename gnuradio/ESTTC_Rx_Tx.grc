options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: no_gui
    id: ESTTC_Rx_Tx
    output_language: python
    title: ESTTC Rx/Tx
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: gfsk_bps
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: gfsk_bt
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: gfsk_freq_dev
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: gfsk_mod_ind
  id: variable
  parameters:
    value: 2 * gfsk_freq_dev / gfsk_bps
  states: {}
- name: gfsk_samp_rate
  id: variable
  parameters:
    value: gfsk_sps * gfsk_bps
  states: {}
- name: gfsk_sensitivity
  id: variable
  parameters:
    value: 2*pi*gfsk_freq_dev/gfsk_samp_rate
  states: {}
- name: gfsk_sps
  id: variable
  parameters:
    value: '50'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: rx_freq_offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: UTAT_HERON_esttc_deframer_0
  id: UTAT_HERON_esttc_deframer
  parameters:
    samp_rate: gfsk_samp_rate
  states: {}
- name: UTAT_HERON_esttc_framer_0
  id: UTAT_HERON_esttc_framer
  parameters: {}
  states: {}
- name: UTAT_HERON_tagged_stream_fixed_length_padder_0
  id: UTAT_HERON_tagged_stream_fixed_length_padder
  parameters:
    filler: '0x01'
    final_buffer_len: 2**17
    final_samples_per_symbol: 8*samp_rate/gfsk_bps
    len_tag_key: packet_len
  states: {}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '100'
    rate: '625e-6'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: tx_freq-freq
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    freq: rx_freq_offset + (freq-rx_freq)
    sample_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: rx_freq
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: tx_freq
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '175e-3'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(gfsk_sps)
    sensitivity: gfsk_sensitivity
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: gfsk_bt
    samples_per_symbol: int(gfsk_sps)
    sensitivity: gfsk_sensitivity
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 0.0.0.0
    gpredict_port: '7356'
    verbose: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '50949'
    type: complex
  states: {}
- name: pdu_add_system_time_0
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("Tx")
  states: {}
- name: pdu_add_system_time_1
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("Rx")
  states: {}
- name: pdu_add_system_time_1_0
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("Rx CRC FAIL")
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '12'
    interp: '25'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '12'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: freq
    dev_args: '"driver=hackrf,serial=9e5f"'
    samp_rate: samp_rate
    type: fc32
    vga: '47'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: freq + rx_freq_offset
    dev_args: '"driver=hackrf,serial=915f"'
    gain: '40'
    samp_rate: samp_rate
    type: fc32
    vga: '50'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:50492
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://*:50491
    bind: 'True'
    timeout: '100'
  states: {}

connections:
- [UTAT_HERON_esttc_deframer_0, crc_fail, pdu_add_system_time_1_0, pdu]
- [UTAT_HERON_esttc_deframer_0, crc_ok, pdu_add_system_time_1, pdu]
- [UTAT_HERON_esttc_deframer_0, crc_ok, zeromq_pub_msg_sink_0, in]
- [UTAT_HERON_esttc_framer_0, pdu_out, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [UTAT_HERON_tagged_stream_fixed_length_padder_0, '0', digital_gfsk_mod_0, '0']
- [analog_agc_xx_1, '0', rational_resampler_xxx_1, '0']
- [blocks_freqshift_cc_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_freqshift_cc_1, '0', low_pass_filter_0, '0']
- [digital_gfsk_demod_0, '0', UTAT_HERON_esttc_deframer_0, '0']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [gpredict_doppler_0, freq, blocks_msgpair_to_var_0, inpair]
- [gpredict_doppler_0, tx_freq, blocks_msgpair_to_var_1, inpair]
- [low_pass_filter_0, '0', analog_agc_xx_1, '0']
- [pdu_add_system_time_0, pdu, blocks_message_debug_0, print]
- [pdu_add_system_time_1, pdu, blocks_message_debug_0, print]
- [pdu_add_system_time_1_0, pdu, blocks_message_debug_0, print]
- [pdu_pdu_to_tagged_stream_0_0_0, '0', UTAT_HERON_tagged_stream_fixed_length_padder_0, '0']
- [rational_resampler_xxx_0, '0', blocks_freqshift_cc_0, '0']
- [rational_resampler_xxx_1, '0', digital_gfsk_demod_0, '0']
- [rational_resampler_xxx_1, '0', network_tcp_sink_0, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_1, '0']
- [zeromq_sub_msg_source_0, out, UTAT_HERON_esttc_framer_0, pdu_in]
- [zeromq_sub_msg_source_0, out, pdu_add_system_time_0, pdu]

metadata:
  file_format: 1
  grc_version: 3.10.8.0
