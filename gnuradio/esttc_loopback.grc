options:
  parameters:
    author: heron
    generate_options: qt_gui
    id: esttc_loopback
    output_language: python
    title: ESTTC Loopback
  states: {}

blocks:
- name: message
  id: variable
  parameters:
    value: '"VE3SGH Test"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_2
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(message), [ord(c) for c in message]))
    period: '1000'
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ip
  id: parameter
  parameters:
    label: Host IP Address
    type: str
    value: 127.0.0.1
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '10'
    minsize: '10'
  states: {}
- name: push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    label: Send
    msgName: pressed
    type: int
    value: '1'
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: '"tcp://"+ip+":50492"'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://"+ip+":50491"'
    bind: 'False'
    timeout: '100'
  states: {}

connections:
- [blocks_message_strobe_2, strobe, zeromq_push_msg_sink_0, in]
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [pdu_random_pdu_0, pdus, zeromq_push_msg_sink_0, in]
- [push_button_0, pressed, pdu_random_pdu_0, generate]
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.8.0
