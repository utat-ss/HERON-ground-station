options:
  parameters:
    author: heron
    generate_options: no_gui
    id: esttc_loopback
    output_language: python
    title: ESTTC Loopback
  states: {}

blocks:
- name: message
  id: variable
  parameters:
    value: '"VE3SGH Test"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_2
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(message), [ord(c) for c in message]))
    period: '1000'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ip
  id: parameter
  parameters:
    label: Host IP Address
    type: str
    value: 10.0.7.38
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: '"tcp://"+ip+":50492"'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://"+ip+":50491"'
    bind: 'False'
    timeout: '100'
  states: {}

connections:
- [blocks_message_strobe_2, strobe, zeromq_push_msg_sink_0, in]
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.8.0
