options:
  parameters:
    author: Swarnava Ghosh
    category: '[UTAT]'
    copyright: University of Toronto Aerospace Team
    description: Already implemented in C++! Check HERON-gr-utat repository.
    generate_options: hb
    id: ESTTC_Framer_GRC
    output_language: python
    title: ESTTC  Framer GRC
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''101010101010101010101010101010101010101001111110'''
  states: {}
- name: hdr_format
  id: UTAT_HERON_header_format_esttc
  parameters:
    access_code: access_code
    bps: '1'
    threshold: '3'
    trailer_nbits: '16'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    final_xor: '0x0000'
    initial_value: '0xFFFF'
    input_reflected: 'False'
    num_bits: '16'
    poly: '0x1021'
    result_reflected: 'False'
    skip_header_bytes: '6'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pdu_out
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: pdu_in
    type: message
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [blocks_tagged_stream_mux_0, '0', pdu_tagged_stream_to_pdu_1, '0']
- [digital_crc_append_0, out, pad_sink_0, in]
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0, pdus]
- [pad_source_0, out, digital_protocol_formatter_async_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_tagged_stream_to_pdu_1, pdus, digital_crc_append_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
