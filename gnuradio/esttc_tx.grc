options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: no_gui
    id: esttc_tx
    output_language: python
    run_options: run
    title: ESTTC TX
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: gfsk_bps
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: gfsk_bt
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: gfsk_freq_dev
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: gfsk_mod_ind
  id: variable
  parameters:
    value: 2 * gfsk_freq_dev / gfsk_bps
  states: {}
- name: gfsk_samp_rate
  id: variable
  parameters:
    value: gfsk_sps * gfsk_bps
  states: {}
- name: gfsk_sensitivity
  id: variable
  parameters:
    value: 2*pi*gfsk_freq_dev/gfsk_samp_rate
  states: {}
- name: gfsk_sps
  id: variable
  parameters:
    value: '50'
  states: {}
- name: hackrf_buf
  id: variable
  parameters:
    value: 2**17
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: UTAT_HERON_esttc_framer_0
  id: UTAT_HERON_esttc_framer
  parameters: {}
  states: {}
- name: UTAT_HERON_tagged_stream_fixed_length_padder_0
  id: UTAT_HERON_tagged_stream_fixed_length_padder
  parameters:
    filler: '0x01'
    final_buffer_len: hackrf_buf
    final_samples_per_symbol: 8*samp_rate/gfsk_bps
    len_tag_key: packet_len
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: gfsk_bt
    samples_per_symbol: int(gfsk_sps)
    sensitivity: gfsk_sensitivity
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      gfsk_samp_rate
      to
      samp_rate
    decim: '12'
    interp: '25'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: freq
    dev_args: '"driver=hackrf,serial=29e5f"'
    samp_rate: samp_rate
    type: fc32
    vga: '47'
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: ipc:///tmp/esttc_tx_stream
    bind: 'True'
    timeout: '100'
  states: {}

connections:
- [UTAT_HERON_esttc_framer_0, pdu_out, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [UTAT_HERON_tagged_stream_fixed_length_padder_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', UTAT_HERON_tagged_stream_fixed_length_padder_0, '0']
- [rational_resampler_xxx_0, '0', blocks_tag_debug_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']
- [zeromq_pull_msg_source_0, out, UTAT_HERON_esttc_framer_0, pdu_in]
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
