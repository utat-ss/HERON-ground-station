options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: no_gui
    id: nbfm_loopback
    output_language: python
    title: NBFM Loopback
  states: {}

blocks:
- name: control_port
  id: variable
  parameters:
    value: base_port
  states: {}
- name: freq
  id: variable
  parameters:
    value: 446.040e6
  states: {}
- name: rx_amp
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: rx_freq_offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: rx_if_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: rx_vga_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: stream_port
  id: variable
  parameters:
    value: base_port+1
  states: {}
- name: tx_amp
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: tx_vga_gain
  id: variable
  parameters:
    value: '47'
  states: {}
- name: volume
  id: variable
  parameters:
    value: '1'
  states: {}
- name: UTAT_HERON_variable_filter_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: freq
  states: {}
- name: UTAT_HERON_variable_filter_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_freq_offset
  states: {}
- name: UTAT_HERON_variable_filter_0_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: squelch_threshold
  states: {}
- name: UTAT_HERON_variable_filter_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_if_gain
  states: {}
- name: UTAT_HERON_variable_filter_1_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_vga_gain
  states: {}
- name: UTAT_HERON_variable_filter_1_0_0
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: volume
  states: {}
- name: UTAT_HERON_variable_filter_1_0_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: rx_amp
  states: {}
- name: UTAT_HERON_variable_filter_1_1
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: tx_vga_gain
  states: {}
- name: UTAT_HERON_variable_filter_1_2
  id: UTAT_HERON_variable_filter
  parameters:
    variable_name: tx_amp
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48e3)
    max_dev: 2.5e3
    quad_rate: int(48e3)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: int(48e3)
    fh: '-1.0'
    max_dev: 2.5e3
    quad_rate: int(48e3)
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: rx_freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_threshold
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: base_port
  id: parameter
  parameters:
    label: Base Port
    type: intx
    value: '52000'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: rx_freq_offset
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: os.environ.get('HOME')+"/Music/message.mp3"
    repeat: 'True'
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_MsgPairToVar_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_freq_offset
  states: {}
- name: gpredict_MsgPairToVar_0_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_vga_gain
  states: {}
- name: gpredict_MsgPairToVar_0_0_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: tx_amp
  states: {}
- name: gpredict_MsgPairToVar_0_1
  id: gpredict_MsgPairToVar
  parameters:
    target: squelch_threshold
  states: {}
- name: gpredict_MsgPairToVar_0_1_0
  id: gpredict_MsgPairToVar
  parameters:
    target: tx_vga_gain
  states: {}
- name: gpredict_MsgPairToVar_0_1_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_amp
  states: {}
- name: gpredict_MsgPairToVar_0_2
  id: gpredict_MsgPairToVar
  parameters:
    target: rx_if_gain
  states: {}
- name: gpredict_MsgPairToVar_0_2_0
  id: gpredict_MsgPairToVar
  parameters:
    target: volume
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: stream_port
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '125'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '12'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_1
  id: soapy_hackrf_sink
  parameters:
    amp: tx_amp
    center_freq: freq
    dev_args: '"driver=hackrf,serial=9e5f"'
    samp_rate: samp_rate
    type: fc32
    vga: tx_vga_gain
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: rx_amp
    center_freq: freq + rx_freq_offset
    dev_args: '"driver=hackrf,serial=915f"'
    gain: rx_if_gain
    samp_rate: samp_rate
    type: fc32
    vga: rx_vga_gain
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: '"tcp://*"+str(control_port)'
    bind: 'True'
    timeout: '100'
  states: {}

connections:
- [UTAT_HERON_variable_filter_0, out, gpredict_MsgPairToVar_0, inpair]
- [UTAT_HERON_variable_filter_0_0, out, gpredict_MsgPairToVar_0_0, inpair]
- [UTAT_HERON_variable_filter_0_0_0, out, gpredict_MsgPairToVar_0_1, inpair]
- [UTAT_HERON_variable_filter_1, out, gpredict_MsgPairToVar_0_2, inpair]
- [UTAT_HERON_variable_filter_1_0, out, gpredict_MsgPairToVar_0_0_0, inpair]
- [UTAT_HERON_variable_filter_1_0_0, out, gpredict_MsgPairToVar_0_2_0, inpair]
- [UTAT_HERON_variable_filter_1_0_1, out, gpredict_MsgPairToVar_0_1_0_0, inpair]
- [UTAT_HERON_variable_filter_1_1, out, gpredict_MsgPairToVar_0_1_0, inpair]
- [UTAT_HERON_variable_filter_1_2, out, gpredict_MsgPairToVar_0_0_0_0, inpair]
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [audio_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_1, '0']
- [rational_resampler_xxx_1, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_1, '0', network_tcp_sink_0, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0, '0']
- [soapy_hackrf_source_0, '0', blocks_multiply_xx_0, '0']
- [zeromq_pull_msg_source_0, out, UTAT_HERON_variable_filter_0, in]
- [zeromq_pull_msg_source_0, out, UTAT_HERON_variable_filter_0_0, in]
- [zeromq_pull_msg_source_0, out, UTAT_HERON_variable_filter_0_0_0, in]
- [zeromq_pull_msg_source_0, out, UTAT_HERON_variable_filter_1, in]
- [zeromq_pull_msg_source_0, out, UTAT_HERON_variable_filter_1_0, in]
- [zeromq_pull_msg_source_0, out, UTAT_HERON_variable_filter_1_0_0, in]
- [zeromq_pull_msg_source_0, out, UTAT_HERON_variable_filter_1_0_1, in]
- [zeromq_pull_msg_source_0, out, UTAT_HERON_variable_filter_1_1, in]
- [zeromq_pull_msg_source_0, out, UTAT_HERON_variable_filter_1_2, in]

metadata:
  file_format: 1
  grc_version: 3.10.8.0
