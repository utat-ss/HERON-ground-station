options:
  parameters:
    author: Swarnava Ghosh
    copyright: University of Toronto Aerospace Team
    generate_options: qt_gui
    id: bladerf_remote_control
    output_language: python
    title: BladeRF Remote Control
  states: {}

blocks:
- name: cfo
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@0: 1, 0, 1, 1'
    label: Osc Freq
    start: 1e6
    step: 250e3
    stop: 6e9
    value: 435.4e6
    widget: counter
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@0: 0, 0, 1, 1'
    label: Frequency
    start: 1e6
    step: 250e3
    stop: 6e9
    value: 435e6
    widget: counter
  states: {}
- name: gfsk_freq_dev
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@2: 2, 0, 1, 1'
    label: GFSK Freq Dev
    start: '1200'
    step: '200'
    stop: '4800'
    value: '2400'
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'control_tab@2: 0, 1, 3, 1'
    label: Mode
    label0: NBFM Audio
    label1: ESTTC
    label2: AX.25
    label3: AX.25 G3RUH
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: rx_lna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'control_tab@1: 0, 2, 3, 1'
    label: RX LNA
    label0: '0'
    label1: '3'
    label2: '6'
    num_opts: '3'
    option0: '0'
    option1: '3'
    option2: '6'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: rx_vga
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@1: 2, 0, 1, 2'
    label: RX VGA
    start: '5'
    step: '1'
    stop: '60'
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@2: 0, 0, 1, 1'
    label: Squelch (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: tx_vga1
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@1: 0, 0, 1, 2'
    label: TX VGA1
    start: '-35'
    step: '1'
    stop: '-4'
    value: '-35'
  states: {}
- name: tx_vga2
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@1: 1, 0, 1, 2'
    label: TX VGA2
    start: '0'
    step: '1'
    stop: '25'
    value: '0'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 'control_tab@2: 1, 0, 1, 1'
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(baseband_samp_rate)
  states: {}
- name: baseband_samp_rate
  id: parameter
  parameters:
    label: baseband_samp_rate
    value: 48e3
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: baseband_samp_rate
    type: complex
  states: {}
- name: control_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0, 0, 1, 1
    label0: Control
    label1: SDR Amps
    label2: Misc
    num_tabs: '3'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: Server IP
    type: str
    value: 10.0.1.165
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: baseband_samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    gui_hint: 1,0,5,1
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: baseband_samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: 0,1,6,2
    type: complex
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_freq
    port: '8080'
    variable: freq
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_cfo
    port: '8080'
    variable: cfo
  states: {}
- name: xmlrpc_client_0_0_0
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_tx_vga1
    port: '8080'
    variable: tx_vga1
  states: {}
- name: xmlrpc_client_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_tx_vga2
    port: '8080'
    variable: tx_vga2
  states: {}
- name: xmlrpc_client_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_rx_vga
    port: '8080'
    variable: rx_vga
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0_0_0_0_1
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_volume
    port: '8080'
    variable: volume
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0_0_0_0_1_0
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_mode
    port: '8080'
    variable: mode
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0_0_0_0_1_1
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_gfsk_freq_dev
    port: '8080'
    variable: gfsk_freq_dev
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0_0_2
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_squelch_threshold
    port: '8080'
    variable: squelch_threshold
  states: {}
- name: xmlrpc_client_0_0_0_1
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_rx_lna
    port: '8080'
    variable: rx_lna
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '''tcp://''+ip+'':''+str(zmq_rx_bb)'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_1
  id: zeromq_sub_source
  parameters:
    address: '''tcp://''+ip+'':''+str(zmq_rx_audio)'
    timeout: '100'
    type: float
  states: {}
- name: zmq_rx_audio
  id: parameter
  parameters:
    label: RX audio
    type: intx
    value: '50493'
  states: {}
- name: zmq_rx_bb
  id: parameter
  parameters:
    label: RX baseband
    type: intx
    value: '52001'
  states: {}

connections:
- [zeromq_sub_source_0, '0', blocks_throttle2_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_sub_source_1, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
