options:
  parameters:
    generate_options: qt_gui
    id: rx_debug
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 435e6
    step: 500e0
    stop: 438e6
    value: 435e6
    widget: counter
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    start: '-20'
    step: '0.1'
    stop: '20'
    value: '14'
  states: {}
- name: rx_bb_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '2'
    stop: '62'
    value: '4'
  states: {}
- name: rx_if_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '8'
    stop: '40'
    value: '8'
  states: {}
- name: rx_rf_gain
  id: variable_qtgui_chooser
  parameters:
    label0: RF Gain ON
    label1: RF Gain OFF
    num_opts: '2'
    option0: '14'
    option1: '0'
    type: int
    value: '14'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: home/adyn/ground-station/recordings/packets_path_packed
    type: complex
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 3*baud_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 3.3333e3
    win: window.WIN_HANN
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    dev_args: hackrf=0000000000000000a06063c8242f915f
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [filter_fft_low_pass_filter_0, '0', blocks_file_sink_0, '0']
- [soapy_hackrf_source_0, '0', filter_fft_low_pass_filter_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
