options:
  parameters:
    generate_options: qt_gui
    id: rx_quaddemod
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: 9.6e3
  states: {}
- name: dc_shift
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-25'
    step: '.5'
    stop: '20'
    value: '2.1'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 435e6
    step: 500e0
    stop: 438e6
    value: 435e6
    widget: counter
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: 2.4e3
  states: {}
- name: packets_path
  id: variable
  parameters:
    value: path+subpath+"potentialpackets"
  states: {}
- name: packets_path_packed
  id: variable
  parameters:
    value: path+subpath+"potentialpacketspacked"
  states: {}
- name: path
  id: variable
  parameters:
    value: '"/home/vogel/Files/ground-station/"'
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-20'
    step: '0.1'
    stop: '20'
    value: '14'
  states: {}
- name: quad_path
  id: variable
  parameters:
    value: path+subpath+"quaddemodsignal"
  states: {}
- name: quadshifted_path
  id: variable
  parameters:
    value: path+subpath+"quaddemodsignal_shifted"
  states: {}
- name: rx_bb_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '62'
    value: '4'
  states: {}
- name: rx_if_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '8'
    stop: '40'
    value: '8'
  states: {}
- name: rx_rf_gain
  id: variable_qtgui_chooser
  parameters:
    label0: RF Gain ON
    label1: RF Gain OFF
    num_opts: '2'
    option1: '0'
    type: int
    value: '14'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1056000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: subpath
  id: variable
  parameters:
    value: '"recordings/"'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-6'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: packets_path
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: packets_path_packed
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '110'
    sensitivity: '0.5'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    comment: Have more samples than I think
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int( (samp_rate/ baud_rate ) )
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    type: ccc
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3*baud_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 3.3333e3
    win: firdes.WIN_HANN
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0000000000000000a06063c8242f915f
    bb_gain0: rx_bb_gain
    bw0: 6*baud_rate
    corr0: ppm
    freq0: freq
    gain0: rx_rf_gain
    gain_mode0: 'False'
    if_gain0: rx_if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/8
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    showports: 'True'
    type: complex
    update_time: '0.001'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 20e3
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: utat_heron_rx_bb_1
  id: utat_heron_rx_bb
  parameters:
    comment: Detects HERON packets
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_gfsk_demod_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_null_sink_0, '0']
- [digital_gfsk_demod_0, '0', utat_heron_rx_bb_1, '0']
- [digital_gmsk_demod_0, '0', utat_heron_rx_bb_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', digital_gmsk_demod_0, '0']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [low_pass_filter_0, '0', digital_gmsk_demod_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']
- [utat_heron_rx_bb_1, '0', blocks_file_sink_0, '0']
- [utat_heron_rx_bb_1, '0', blocks_pack_k_bits_bb_0, '0']

metadata:
  file_format: 1
