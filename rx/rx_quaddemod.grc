options:
  parameters:
    generate_options: qt_gui
    id: rx_quaddemod
    output_language: python
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: 9.6e3
  states: {}
- name: dc_shift
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-25'
    step: '.5'
    stop: '20'
    value: '2.1'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 435e6
    step: 200e3
    stop: 438e6
    value: 435e6
    widget: counter
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: 2.4e3
  states: {}
- name: packets_path
  id: variable
  parameters:
    value: path+subpath+"potentialpackets"
  states: {}
- name: packets_path_packed
  id: variable
  parameters:
    value: path+subpath+"potentialpacketspacked"
  states: {}
- name: path
  id: variable
  parameters:
    value: '"/home/ghs/utat/ground-station/"'
  states: {}
- name: quad_path
  id: variable
  parameters:
    value: path+subpath+"quaddemodsignal"
  states: {}
- name: quadshifted_path
  id: variable
  parameters:
    value: path+subpath+"quaddemodsignal_shifted"
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1056000'
  states: {}
- name: subpath
  id: variable
  parameters:
    value: '"recordings/"'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*freq_dev/8.0)
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: dc_shift
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: dc_shift
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: packets_path
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: packets_path_packed
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: quad_path
    type: float
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: quadshifted_path
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '.1'
    gain_omega: '0'
    mu: '0'
    omega: (samp_rate/baud)/10
    omega_relative_limit: '0'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 3.3333e3
    win: firdes.WIN_HANN
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 9.6e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 4.8e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0000000000000000a06063c8242f915f
    bb_gain0: '24'
    bw0: 20e3
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '24'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    showports: 'True'
    type: complex
    update_time: '0.001'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: utat_heron_rx_bb_0
  id: utat_heron_rx_bb
  parameters: {}
  states: {state: disabled}
- name: utat_heron_rx_bb_1
  id: utat_heron_rx_bb
  parameters: {}
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_file_sink_1_0, '0']
- [blocks_add_const_vxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_file_sink_1_0, '0']
- [blocks_add_const_vxx_1, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0_0, '0']
- [digital_binary_slicer_fb_0, '0', utat_heron_rx_bb_0, '0']
- [digital_binary_slicer_fb_0, '0', utat_heron_rx_bb_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_1, '0', blocks_add_const_vxx_0, '0']
- [low_pass_filter_1, '0', blocks_add_const_vxx_1, '0']
- [low_pass_filter_1, '0', blocks_file_sink_1, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [utat_heron_rx_bb_0, '0', blocks_file_sink_0, '0']
- [utat_heron_rx_bb_1, '0', blocks_file_sink_0, '0']
- [utat_heron_rx_bb_1, '0', blocks_pack_k_bits_bb_0, '0']

metadata:
  file_format: 1
