options:
  parameters:
    generate_options: qt_gui
    id: rx_testing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: 9.6e3
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: dc_shift
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-25'
    step: '.5'
    stop: '20'
    value: '2.1'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: freq_0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 435e6
    step: 200e3
    stop: 438e6
    value: 435e6
    widget: counter
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: 2.4e3
  states: {}
- name: msg_file
  id: variable
  parameters:
    value: path+"cmdout.bin"
  states: {}
- name: packets_path
  id: variable
  parameters:
    value: path+subpath+"potentialpackets"
  states: {}
- name: packets_path_packed
  id: variable
  parameters:
    value: path+subpath+"potentialpacketspacked"
  states: {}
- name: path
  id: variable
  parameters:
    value: '"/home/vogel/Files/GitHub/ground-station/"'
  states: {}
- name: path_0
  id: variable
  parameters:
    value: '"/home/vogel/Files/GitHub/ground-station/"'
  states: {}
- name: quad_path
  id: variable
  parameters:
    value: path+subpath+"quaddemodsignal"
  states: {}
- name: quadshifted_path
  id: variable
  parameters:
    value: path+subpath+"quaddemodsignal_shifted"
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sps*baud_rate
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '1056000'
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: '1056000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: subpath
  id: variable
  parameters:
    value: '"recordings/"'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: packets_path_packed
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: packets_path
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: msg_file
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_tx
    type: complex
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: sps
    sensitivity: '.15708'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    comment: SPS needs to change based on resampler
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int( (samp_rate_tx / baud_rate ) )
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Cutoff freq is somewhat empirical
    cutoff_freq: 3*baud_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_tx
    type: fir_filter_ccf
    width: 3.333e3
    win: firdes.WIN_HANN
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_tx
    fc: '0'
    fftsize: '1024'
    name: Filtered
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    alias: Help Me
    bw: samp_rate_tx
    fc: '0'
    fftsize: '1024'
    name: Unfiltered
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_tx
    taps: ''
    type: ccc
  states: {}
- name: utat_heron_rx_bb_1
  id: utat_heron_rx_bb
  parameters: {}
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0_0, '0']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [digital_gmsk_demod_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_gmsk_demod_0, '0', utat_heron_rx_bb_1, '0']
- [low_pass_filter_0, '0', digital_gmsk_demod_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']
- [utat_heron_rx_bb_1, '0', blocks_null_sink_0, '0']
- [utat_heron_rx_bb_1, '0', blocks_pack_k_bits_bb_0, '0']

metadata:
  file_format: 1
