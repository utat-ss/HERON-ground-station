options:
  parameters:
    generate_options: no_gui
    id: gfsk_tx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '47'
    value: '30'
  states: {state: disabled}
- name: if_gain
  id: variable
  parameters:
    value: '16'
  states: {}
- name: msg_file
  id: variable
  parameters:
    value: path+"cmdout.bin"
  states: {}
- name: path
  id: variable
  parameters:
    value: '"/home/vogel/Files/ground-station/"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sps*baud_rate
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: '1056000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: msg_file
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: sps
    sensitivity: '.15708'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0000000000000000a06063c825429e5f
    bb_gain0: '0'
    bw0: 6*baud_rate
    corr0: '13'
    freq0: freq
    gain0: '14'
    if_gain0: if_gain
    sample_rate: samp_rate_tx
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_tx
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_tx
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
